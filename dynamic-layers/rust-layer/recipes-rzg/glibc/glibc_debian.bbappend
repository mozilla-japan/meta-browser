FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"
SRC_URI += "file://0001-Increase-the-DTV_SURPLUS-value-to-load-many-librarie.patch \
           "
