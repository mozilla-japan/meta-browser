# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36252ac5fb94ae66986a0820fa7dfb8c"
SRC_URI[sha256sum] = "3e1f0435c755382a79f0bde563ea59b8f35fa22ebdffd33d611da54ce2a24b63"
