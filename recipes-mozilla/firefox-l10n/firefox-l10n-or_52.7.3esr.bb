# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8faf6984bb16240faa2a6bd25549cdca"
SRC_URI[sha256sum] = "f4d528d0c9dfb3846ea2b24b9404dc23f3b4e1e174ff9796325da7b2b334d9e3"
