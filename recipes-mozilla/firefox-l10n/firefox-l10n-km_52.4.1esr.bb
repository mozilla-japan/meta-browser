# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1185422cc53ed1b50112d70bba465351"
SRC_URI[sha256sum] = "db7abea12adc054d08580c1d24282a1eca63abfd4fef4159ae4bea83f94423c0"
