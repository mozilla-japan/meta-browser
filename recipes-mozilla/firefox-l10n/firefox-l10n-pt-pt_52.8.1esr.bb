# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "efb3d5ea4155d73ce1fe3b35ec8a1092"
SRC_URI[sha256sum] = "f4f17bed7e66b09728072f34b62b6523e0d05e04b83014299ffaf610e731058e"
