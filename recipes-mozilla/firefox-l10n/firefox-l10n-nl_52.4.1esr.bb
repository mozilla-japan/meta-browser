# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1daed6f87ceb06355e37d4ee54f01223"
SRC_URI[sha256sum] = "5276d86fccdaff5666c7b1a8f553fa50c3e97ff9ac4ef1ce6ffa0c519a0d7cda"
