# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c4c5f940e413c3e92cfb461a54e50d6e"
SRC_URI[sha256sum] = "edbe13a53ab97555ed6392b7550cf7742da4ad8a2e43da159d3a3439cb95a529"
