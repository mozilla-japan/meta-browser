# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4fa1ef96403d27973a53d89701a9e47"
SRC_URI[sha256sum] = "d18513821ddb69e7dd8d5f65e5f0a73b562a98bfe725afd53ab12b40c1719d50"
