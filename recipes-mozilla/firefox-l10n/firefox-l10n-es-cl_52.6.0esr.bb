# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fadb8ae93607c21246bf5dae174cf473"
SRC_URI[sha256sum] = "e35b9086d967680cd00b182ebeebbc8d15d3ad3a094022187737ee93f17ea7a2"
