# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1fe8b7a1a2ddaeb7e60ba3cfbbedc63b"
SRC_URI[sha256sum] = "ca6cea7ea6d0d208320518da87c728f98ddc3a6f7774040eb1ab5fd33b878270"
