# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c73b77baf22a3e9102706b229cb9c72"
SRC_URI[sha256sum] = "686b6b8adb998aeae598be3a7c9cd7e5677cca8ce93271e52b95adf408c393ac"
