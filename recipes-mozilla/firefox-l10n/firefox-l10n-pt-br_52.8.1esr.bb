# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8daf4f51955832fea2d0798c5bd5fb9d"
SRC_URI[sha256sum] = "c8978edceb8d31e7ddee3e68c99eaa3c67efd12e8f1e53eb8089749ae4ddb326"
