# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "864047af50a38f3340fc49d0bcacda08"
SRC_URI[sha256sum] = "d38ae763549352d76ceed9c8b02411449f209d84728f06d75aed755ae9a6603e"
