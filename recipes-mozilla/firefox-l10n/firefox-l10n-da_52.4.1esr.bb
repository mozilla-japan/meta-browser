# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba38ad1fbdb3cef024562e5d06c2bee1"
SRC_URI[sha256sum] = "cee918879d394676bc0c3c40d25aa70c84d8969af09078de714dfe6bd31dc254"
