# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1508975d9c371b795b60ae543ee3be08"
SRC_URI[sha256sum] = "9201c347c734036c971266b82e48d584c75dd0f310890f6de153a74db2076736"
