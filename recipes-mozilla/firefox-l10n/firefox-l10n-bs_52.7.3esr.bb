# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fc6f2298c9b8544fd2ca9f3f5a96864d"
SRC_URI[sha256sum] = "1d0405c2bdadb3afb21bc876df8a0964fcad517b5e52733324dbb9bbb11de5bc"
