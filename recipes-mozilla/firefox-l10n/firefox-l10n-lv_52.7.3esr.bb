# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84bab864f110f27318d7364cd854d989"
SRC_URI[sha256sum] = "f7f2a89c10c8e2d751aac3a80fe8834b6fc3036a9e86d3cbea6b678dc13208c3"
