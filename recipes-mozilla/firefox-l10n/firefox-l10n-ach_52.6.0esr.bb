# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "76efa20d138fc887773f09ec310ba236"
SRC_URI[sha256sum] = "474a766a4083bff88c3a00d407cf971b2a370a070e4c8932b4fdd94e5a96d9b2"
