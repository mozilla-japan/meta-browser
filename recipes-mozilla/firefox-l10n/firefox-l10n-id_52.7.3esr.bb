# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1665d3f15fd712ad891b4070050daea0"
SRC_URI[sha256sum] = "424d91d3f4d2baced287c39680f8a3520691dd845bfecae9676273ce45ec8a3a"
