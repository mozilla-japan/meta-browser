# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "181d0289a3796d3a0cdab3746ce4e328"
SRC_URI[sha256sum] = "a69dc84defc8c777a7ff19fa3554aab9fbfd3cb268abdc2049034dc7acbcc189"
