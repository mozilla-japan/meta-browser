# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fe9a9b6598b7f31e6496801daf8d65fb"
SRC_URI[sha256sum] = "b60630fef863824af52a7495f74f83107057e889a1d595f018e11b6bc1742e10"
