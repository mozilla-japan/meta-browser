# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a45882e6d4fab0a9826e364ef7594dd"
SRC_URI[sha256sum] = "408d13cab9eec8dba25caa288240612b018329a484fdac20a8e7a8fa458c4251"
