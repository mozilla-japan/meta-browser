# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b39798aba4ba5fa7429ddae42b2a89da"
SRC_URI[sha256sum] = "9426ded8fec255e3177a44a88e85d3aa4a635db013298600b3b3468823ece77a"
