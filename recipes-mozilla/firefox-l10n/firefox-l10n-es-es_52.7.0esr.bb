# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "88c23cd9b5613ae4120ed69ce2278e51"
SRC_URI[sha256sum] = "0fdbd13b574571fd8b0f1243f27eb3e1a20ce869f19052aecea333e8eb86cf46"
