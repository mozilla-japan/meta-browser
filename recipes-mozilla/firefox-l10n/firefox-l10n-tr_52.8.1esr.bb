# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8f683539503c45f396186d5962e4a72"
SRC_URI[sha256sum] = "cbc575ed5673066f3700dfe60194cb437cb4218e8cdf4e070b787dd9b5554b71"
