# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f342519301533092f408eece66964d12"
SRC_URI[sha256sum] = "161a266089d3ad502d4808e678996114dc0967769eac14d8c06334480f344f48"
