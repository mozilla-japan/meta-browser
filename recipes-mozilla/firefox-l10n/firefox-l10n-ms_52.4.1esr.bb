# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7e2d92ef5557cd0ab65541de1b2546e"
SRC_URI[sha256sum] = "e0871765f760c44befc34a3206bd4942afa10b068673e7a5b1f9891bc265d422"
