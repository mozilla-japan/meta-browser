# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38c36136ff2b3b1b11a0b37328f2055f"
SRC_URI[sha256sum] = "71856b8a36fdac065e8f20c99b0a1ed9efb928ca80a1cfe9eb03a475907f72af"
