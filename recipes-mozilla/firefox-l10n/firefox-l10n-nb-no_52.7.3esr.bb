# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae08eabed16316dc304a399e3ee287de"
SRC_URI[sha256sum] = "140726232fa50aa2aaa43f0937b76e2c12b07e222285a613560cfbc579859396"
