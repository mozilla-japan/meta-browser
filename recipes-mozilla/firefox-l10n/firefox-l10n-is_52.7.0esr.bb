# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cd091494f9746cec8670d49b9dd3b2c5"
SRC_URI[sha256sum] = "4a32b47b2ca68c30022c68c5f8c5d2bce3ef0d9050c88ecc99053ed42d29f8b9"
