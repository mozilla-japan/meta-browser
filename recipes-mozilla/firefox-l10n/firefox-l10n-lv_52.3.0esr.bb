# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5e32c1bee3b706da6c5162d6da6c010"
SRC_URI[sha256sum] = "7f51052a2f1304401bb75282cce13d00b2a11775fe53e459047d94f33e0676fc"
