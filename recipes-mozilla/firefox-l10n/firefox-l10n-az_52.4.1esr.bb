# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "004bbd8c4240af79fb44909e869fcac8"
SRC_URI[sha256sum] = "d8a2fcc745da94e77cc942a85acd9aa82b8ac51b389abb66c022f25dac0516c1"
