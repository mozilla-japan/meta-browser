# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3cf7bc0d25f382868e73287d9e5e7d42"
SRC_URI[sha256sum] = "7493ef3d013e402e8cb7e04f63f01da9554765ed55697f8cf9f8d4bfc863b6f7"
