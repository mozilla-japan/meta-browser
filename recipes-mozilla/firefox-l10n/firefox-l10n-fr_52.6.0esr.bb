# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43849ada3298e6e61868c69a7974ff54"
SRC_URI[sha256sum] = "a73f6b2848198d38b9a6ce4f61fd706aad862cf77929c7c271efb94c5c75c0fc"
