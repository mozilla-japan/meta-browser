# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b667529ccd07f1ef9e440a219c95354"
SRC_URI[sha256sum] = "e1a7df84195861ded817f8baecd6816217492e2a30fc8a031fe5643bb6e90b13"
