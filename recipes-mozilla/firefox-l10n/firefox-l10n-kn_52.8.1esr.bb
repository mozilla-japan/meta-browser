# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7c20c134538b129a4a93811533e0730"
SRC_URI[sha256sum] = "b62ea2f7ccb0ba081d28d447feed6d656907ed806e27c8e9b32b96930592e1a9"
