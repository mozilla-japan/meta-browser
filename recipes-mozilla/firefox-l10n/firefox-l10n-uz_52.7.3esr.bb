# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f79ca056efb7bf2088b1d6feebc804cc"
SRC_URI[sha256sum] = "e8cbc524b0bcf503eb64286345658aa89a3162398b9b9f24c8fd12c2d11df772"
