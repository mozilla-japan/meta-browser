# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "87a90e3f2a0ec00f06a11684d659056f"
SRC_URI[sha256sum] = "8320d43b219d9f6d3c5dc66235d1942901aaf576c3ec4ac2fbaffc4cf4228211"
