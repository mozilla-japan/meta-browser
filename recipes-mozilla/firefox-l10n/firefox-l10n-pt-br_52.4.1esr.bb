# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "87f4e06e576c5fa3781933f20c683258"
SRC_URI[sha256sum] = "5bd62b7a851abc6051feead9cdb3966411e154822a0a890db6ad9c3ba711177b"
