# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d25ed22ff7657741298450906bf8f47e"
SRC_URI[sha256sum] = "9e6f3a17527edfe2d4c252358ed2dc793b6c87344d6a41ca21027fdf46273381"
