# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f12aec3608fed6e2c0cd62050aa1d76"
SRC_URI[sha256sum] = "262de092845803cf6df209222c36f88294c9a2426e4c52ef0a9ed681d0791294"
