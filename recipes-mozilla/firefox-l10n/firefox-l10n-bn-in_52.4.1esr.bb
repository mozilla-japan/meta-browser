# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8999e9e05312025453c6018c32b71e9d"
SRC_URI[sha256sum] = "508a2872b65159b79847d670f2b9afe7c812239faa86125951aa41ddcec8874c"
