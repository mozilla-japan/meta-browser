# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da41ed2190e8dc358038f52bac8f0675"
SRC_URI[sha256sum] = "03e52e597f0e04425d0ffa44681ca824742f4967e2043042f5dc904e785df2b0"
