# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7505095732b424f9c3e3d06810ea06ad"
SRC_URI[sha256sum] = "ced1286a91e7c870814fe38247805bed009f12fcc3b527a0b990fc946efb7846"
