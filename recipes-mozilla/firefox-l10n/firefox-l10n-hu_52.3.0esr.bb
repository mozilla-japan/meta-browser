# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "915bec480f602f080c4d7feaeab477e6"
SRC_URI[sha256sum] = "a601b2d34694509cc21bb3c5c946e888a91493718814b9ba47836cc8f8ad6645"
