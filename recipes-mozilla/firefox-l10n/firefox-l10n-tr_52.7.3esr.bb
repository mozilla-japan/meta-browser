# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3a18aa3cde0ba38eed9b9cbad8057d6e"
SRC_URI[sha256sum] = "26cb6be326e4768a6c12fb647cf3b7ca50a6e553249dc8c36d847e1ad3734cad"
