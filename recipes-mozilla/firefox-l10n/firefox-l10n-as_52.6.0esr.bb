# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b26df4ba9384e6eaabc9c82442d0a9a0"
SRC_URI[sha256sum] = "6d418734c5bf65f36c607b28d7047f2033aa19f2299c98956816f10e407b9af1"
