# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f5994990f860e254ac663d6e7b15912c"
SRC_URI[sha256sum] = "958a0cc344f19e5fc73b65243582f13b103bd89bd3ad8d2edaae4452e05892f1"
