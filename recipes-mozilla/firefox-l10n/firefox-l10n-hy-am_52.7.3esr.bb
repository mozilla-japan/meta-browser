# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b9d57c097f4d5df185e82459b8e1f723"
SRC_URI[sha256sum] = "fc8b5afa2690624e72a3c8c9d8331f563d9bb16c3cad83fa9ae3636dacd20a8e"
