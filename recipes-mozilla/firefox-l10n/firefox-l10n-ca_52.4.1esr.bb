# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9823726adffb2369b070b07f10636cb5"
SRC_URI[sha256sum] = "8f715f324cb16925839a6c3fde79abaae2aac82eaab11dacea02a64315b45949"
