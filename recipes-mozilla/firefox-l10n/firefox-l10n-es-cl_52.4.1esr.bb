# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "320e9999c3251ba74c0cf22029c92f81"
SRC_URI[sha256sum] = "04ffc521f5c19b2f541a9427a263e391e7fcb661cd79b94964cb266c0b973abf"
