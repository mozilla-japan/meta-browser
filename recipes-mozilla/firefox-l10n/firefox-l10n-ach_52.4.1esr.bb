# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "16d926b45cb7c0e4a2594d886da8c64d"
SRC_URI[sha256sum] = "00f1d648199afaadc072689ba9ac7c79d515a91196ecba4a675ce11ce320c67c"
