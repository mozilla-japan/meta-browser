# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4c221520efa9aea5cde84eff65d9811d"
SRC_URI[sha256sum] = "a729667aee8e3866bf4c036ea6008907cc77b8584451139f285d2333c227ec08"
