# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1232fde6867dc70b411f0bed9a9ca5e6"
SRC_URI[sha256sum] = "3d09b0c0d2a3194f6485ef6e6f678f8950a7882ae8074b196777ba85154ba8fc"
