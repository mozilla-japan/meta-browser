# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f8a52c290b9d1457812d6fb863e65ef"
SRC_URI[sha256sum] = "ec7b22109e53df503557f16319ba47c61ac2af913be280749d09fa6d8de3394c"
