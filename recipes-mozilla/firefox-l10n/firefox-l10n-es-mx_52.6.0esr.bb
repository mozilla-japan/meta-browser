# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef12257588b46a858b16684c3ba005c6"
SRC_URI[sha256sum] = "7ff49cd278e4c106aaebdd4198a3a8167afc23705b050ef904da413bcb46c823"
