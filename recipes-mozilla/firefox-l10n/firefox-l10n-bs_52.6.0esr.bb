# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b579177f4f90adf3cc5106ae0b151f95"
SRC_URI[sha256sum] = "54d3c490eadb78544d48525ac8ce24d184e0d5fcb831b537b39f748a61170d19"
