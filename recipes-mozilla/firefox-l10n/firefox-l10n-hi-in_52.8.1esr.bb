# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fdc4dc787fcbb2caafbd1334de7a400a"
SRC_URI[sha256sum] = "45c9d6414e360ff8d9250d790b534ec3a53a4073406fa46ec0bb4e86ffd33b70"
