# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c07cc8d3b0185b1d4abf9a3785018829"
SRC_URI[sha256sum] = "465c067184efdec93c8d8f4678ece0e1acfae458fc7caa646fa3e7b26a1f5e83"
