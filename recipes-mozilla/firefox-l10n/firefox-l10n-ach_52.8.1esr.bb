# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c756de69d2940b13dee1bd5a1fdcef20"
SRC_URI[sha256sum] = "632b6e2b6317144071f983eccdbc4ae1d5ab188b80b05f855862ade0fe366663"
