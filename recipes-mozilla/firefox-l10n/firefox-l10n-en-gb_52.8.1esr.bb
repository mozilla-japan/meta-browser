# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ff39297f262e45cffd2f386dd56dad73"
SRC_URI[sha256sum] = "5376b09cd3b4b6dc7cb192b6db4cc40cb5fe3f9131ebaed8a7ceb32f0874587f"
