# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5cc26e0003a033a3df7695346c83b26"
SRC_URI[sha256sum] = "54ab52c80cc44c324ed0ef3e027552f01632d4050e64877d968f73756228ec4e"
