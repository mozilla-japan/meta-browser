# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "634277e3ec42bd4d83dda36a7b6f05c0"
SRC_URI[sha256sum] = "087facfa5111278b3f98c2f27edd1555641dc933472b2b18a202f3d06c20d709"
