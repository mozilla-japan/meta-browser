# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c49e311a8fa262f642e570ff9c6faef0"
SRC_URI[sha256sum] = "8cb4fce391249e1716f721def592776e6cccc47eaaeb254342b263683ff9b8a6"
