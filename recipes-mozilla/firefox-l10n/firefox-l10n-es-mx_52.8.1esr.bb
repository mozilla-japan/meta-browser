# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef9da5784560a6291369430a6d4919fd"
SRC_URI[sha256sum] = "d14ab4075bf8a659f86910db024ad7141ed6b27e4487664845f60e2e39afb351"
