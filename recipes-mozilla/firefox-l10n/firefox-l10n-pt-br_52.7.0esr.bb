# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1137c0d17a2d6c8b84f60f679ff61297"
SRC_URI[sha256sum] = "e96e12a761bf1879dcd6e8a40126d725abb55242308a2fe3888c93dfcb192e1c"
