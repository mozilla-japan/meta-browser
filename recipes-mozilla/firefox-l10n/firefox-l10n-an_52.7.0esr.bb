# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b81c33a1948dc99d9fe280479bbb1e06"
SRC_URI[sha256sum] = "8dcd84c821ca407ed6d7f885dcac0f135cac5fb5701b712c50e5df252b5ac34b"
