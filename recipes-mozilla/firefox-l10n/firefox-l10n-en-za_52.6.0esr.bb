# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b5ecd8493488bbf5b984cbfee0f2cf7e"
SRC_URI[sha256sum] = "36ad00ad00a88639edf7c6420894ce6c816dc3952978cc7156d015fd8445fee6"
