# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e566d8b6c379ce859a2eab0c3feccbf"
SRC_URI[sha256sum] = "b480a33a10a103cb49e958c282def98c1a0f3f61dc8901ce358a14ea7a258e11"
