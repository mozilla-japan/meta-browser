# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bdd044a609cad80aac31d4223afc01a2"
SRC_URI[sha256sum] = "05200d2f3aeec9328028dc4df68c17498e1289dd44663c36fed024e315554b89"
