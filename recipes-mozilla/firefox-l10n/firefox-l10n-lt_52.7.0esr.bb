# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7b1d42b7446e614cc2f0bd56b9c1466e"
SRC_URI[sha256sum] = "65dbdf5b942c8cb42d02ca806914f91d58f8053e3db0e5d70090ee47a40e1f74"
