# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "110d1acafe440be57a33eb8721663921"
SRC_URI[sha256sum] = "3830fe2cfcb78012b3283539739563977c9b49bac85274b34cda98996301ecc3"
