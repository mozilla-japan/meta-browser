# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7c0d8732294fc794851dd884e0c5001"
SRC_URI[sha256sum] = "20e93f9d23e887d664f9e6a96032b27479ff5709941481c47c112718402a7c5f"
