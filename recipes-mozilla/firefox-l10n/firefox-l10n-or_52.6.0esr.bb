# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7a129c4c23fb16e724c0e42ac8d5abd9"
SRC_URI[sha256sum] = "7a99747d95b2f38f91cfbb14c4d5b500a731d2a568db6b1e3baf466e84428193"
