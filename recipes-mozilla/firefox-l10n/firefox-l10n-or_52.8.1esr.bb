# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f0060d76728453aedce59b8eed71c183"
SRC_URI[sha256sum] = "1b2d3ead83c1191056d7a913e452149e526452c696e465ee91cbee71c4590203"
