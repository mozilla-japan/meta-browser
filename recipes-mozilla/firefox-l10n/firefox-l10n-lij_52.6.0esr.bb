# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5421c5183286844bdaf987826d7933bb"
SRC_URI[sha256sum] = "d55b2d2d450b390b00e83b9781454ae7a08365a0b0fcfe3e748b23b117952b11"
