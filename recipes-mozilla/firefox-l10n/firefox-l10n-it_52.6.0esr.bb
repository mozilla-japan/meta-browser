# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "72c3ea15059be959f0ce52e57f63b03d"
SRC_URI[sha256sum] = "b83554d0e33353100add2f2dec25027a2dccb7c71236a46494ac83009e0f097f"
