# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ee985441b9268cf6a7e1f0f75d2e661c"
SRC_URI[sha256sum] = "1763a916bb9ad644ca9541a04a858e913a807428113f4ca7190eec31b16b1826"
