# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "61119fa9e747d73d91b5282346558e95"
SRC_URI[sha256sum] = "ae523a1649c133d895f61b1da543d612d5fdb309fc0131299320a5755447bc2e"
