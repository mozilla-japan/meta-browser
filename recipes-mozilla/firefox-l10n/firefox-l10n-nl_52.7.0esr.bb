# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c87d98fc06d8247d9b53929ed9cc4691"
SRC_URI[sha256sum] = "e83dbb8858cee1aaa2eb722aa1e9baca54d09dc0d85e08c51668c8c3df11beb4"
