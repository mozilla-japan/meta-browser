# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d15012064b9a684a7364c96ad928528a"
SRC_URI[sha256sum] = "2b2fc43d885425b4a4df79d9ed7e21ade80d104d7d318af067b1093a58fe2aa0"
