# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0746369605ebf09592af827698d3399"
SRC_URI[sha256sum] = "8fd435ee44ff29e97f91e5cad9e558453c94618b43651c0c1bf60940fad388c8"
