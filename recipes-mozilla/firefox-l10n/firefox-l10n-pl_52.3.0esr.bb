# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cbf12b1d2c04f3dfbed48a8ac682851f"
SRC_URI[sha256sum] = "488fb4dc5e2c6dfb72d0c093dc0489ced730117f85154027a68b61d53046a120"
