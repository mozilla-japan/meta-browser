# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d6cab8ca45ee052d56f7f8e56775e5ba"
SRC_URI[sha256sum] = "03c092ebff9ca36eab846da53bc9eba8ecf0e6c56a32c4f45e4cd8d82221bd5e"
