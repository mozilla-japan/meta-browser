# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7f490a95c7fa31d3d660cdeb597cc2a"
SRC_URI[sha256sum] = "4716e54094a90dfa8b3f49803f20a46b7558a774f83a730abca70903ce399cf4"
