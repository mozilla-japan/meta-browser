# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9bd6607383e5645ac9481829d7cfe2fd"
SRC_URI[sha256sum] = "6ba2abe14a8b2506967f0ef44290ef37929ec964c821f9b4b35b4bf9ef944d17"
