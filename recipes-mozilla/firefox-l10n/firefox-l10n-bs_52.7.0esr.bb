# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ab3ac6cdea9bd32711be3ca1b9a04eb"
SRC_URI[sha256sum] = "019081b23d5f8880bc8c12b8b6dedef1fb2004a10f404665faaf860a0c1086b4"
