# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6d6a7462b7bc0d69fc7ac09e7bf782c"
SRC_URI[sha256sum] = "584381823fee0903f18c90b5b9240a1a482041fef664413b240cb4d19ec77875"
