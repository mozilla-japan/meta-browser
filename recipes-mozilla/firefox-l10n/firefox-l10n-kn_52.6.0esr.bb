# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2efba7ebdca83b94e37d827aa2aee554"
SRC_URI[sha256sum] = "1bb480998c9e869545f2ceb7ad7df52c554270aad5ce2c0a5442371c963a7a48"
