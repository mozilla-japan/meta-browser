# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa9f92cbeabd470f08ccfe9392a3d741"
SRC_URI[sha256sum] = "29fa4dc8bad69fe943baf9c089ff1f27c3a42e42dde597823742dfbd96a7752c"
