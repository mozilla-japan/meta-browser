# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e471ebcfac3b2b4e2c2b6542557cd3ea"
SRC_URI[sha256sum] = "ccca0f3cd155b40cefb27404116b6721567b5c05c37ea8836aa1206d272967da"
