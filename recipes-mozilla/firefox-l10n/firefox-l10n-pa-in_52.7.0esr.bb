# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "921f4871c009f4df35283f2bb0a2eeb2"
SRC_URI[sha256sum] = "8f81cd036bdcd6db9f6e6bad83dd4cc67ddde6c31229f22f57ef7ac5acb6f183"
