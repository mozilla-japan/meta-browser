# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2a9dfb45d7d81bda06b040dfa1dcb462"
SRC_URI[sha256sum] = "f4cece470c8664c9c47086f16853a269405dae41dd5db0d3e77f8f61a6d65629"
