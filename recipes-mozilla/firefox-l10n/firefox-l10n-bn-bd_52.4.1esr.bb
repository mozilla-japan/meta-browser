# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4fea37f89d8455eefd0df0057a0802fc"
SRC_URI[sha256sum] = "0af55cf800780a633f6831dc503f5ed2346f024b67f38e2a3890ad0045d80326"
