# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32bc86193e96898347169aa9b1183233"
SRC_URI[sha256sum] = "666e308a546cf01b92b59e55a50ff96a005ed9beb469db8928460a5b378e41d0"
