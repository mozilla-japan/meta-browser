# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a3b1b5b50b5e100ee4bc43bab18f633e"
SRC_URI[sha256sum] = "0bb07e6d635a2232b8082dd39013ca49de04a2e2fe5352bcdcdd19a6b533d079"
