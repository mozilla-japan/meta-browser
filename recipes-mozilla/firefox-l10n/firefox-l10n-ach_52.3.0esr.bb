# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7cbc6d566ab9e16be94ef5c9d84c5a5"
SRC_URI[sha256sum] = "c0aacc28486d754902edbbbe50ed183abad204a8cce75b11863e1cf96a60d825"
