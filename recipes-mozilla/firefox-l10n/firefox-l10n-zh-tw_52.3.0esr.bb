# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "342fe4d1e2860af242b79d4976df9317"
SRC_URI[sha256sum] = "664a51f492f2e41479c99b16295c3ce1925de11f72dee61408ed1313950f613a"
