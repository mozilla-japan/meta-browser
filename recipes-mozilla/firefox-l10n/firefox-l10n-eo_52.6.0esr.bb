# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5c1bd4334807cda8f51ed715d6df4ef"
SRC_URI[sha256sum] = "b8432617a8ed4e58464e989da0fa2dc292aaa36fdbed98ff4ef5ddf95076b338"
