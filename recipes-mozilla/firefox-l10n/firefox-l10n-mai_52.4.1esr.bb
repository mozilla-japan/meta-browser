# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ddff8ce90d912e74d7cc110e578dfd67"
SRC_URI[sha256sum] = "3ccd983b9dd0a3e51c81e0da07bd783f0ebf16b6cabff00a37b979b4aa6951d3"
