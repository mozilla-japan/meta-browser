# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64f3ba7c71062b495dd8125af8d1906c"
SRC_URI[sha256sum] = "325a5762d8641897f9491956c0d28f8c2ff7b0545cf42d9e504841a5f1e384f0"
