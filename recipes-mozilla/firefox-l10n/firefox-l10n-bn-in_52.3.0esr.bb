# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8c7fbea9d0e0fc394a8bcbd21be93356"
SRC_URI[sha256sum] = "d66093cc936920feb983c1489d6cce00c8fa8a0bf9bb5330ceb7f5d78e871e61"
