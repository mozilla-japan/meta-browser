# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d95611dbfd99ed5d1a3c6f32cefa0212"
SRC_URI[sha256sum] = "de02d6e4f2deb88648e64b29e2ead85952061001bef99d1fec41fe842a8e1d8c"
