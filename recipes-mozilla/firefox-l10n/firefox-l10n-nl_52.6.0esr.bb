# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0dbd1b1e110b2617c165a07bb3cc282f"
SRC_URI[sha256sum] = "5bfae14edb40888d57d092108270ce067ba52150caa39ba83d0f2d57061d0136"
