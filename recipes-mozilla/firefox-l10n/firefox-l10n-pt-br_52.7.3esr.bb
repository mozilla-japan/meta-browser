# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cb9f1dc711cb3fdaacbd0356592363fd"
SRC_URI[sha256sum] = "4fd2e1f7a0d81c62f0cf6ea0adcc4a73af536002efdf8632d106c7257014792e"
