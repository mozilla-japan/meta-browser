# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "83766848a98b86d9f0025d88e890d90a"
SRC_URI[sha256sum] = "cb5c48d14ec999d8292491b568925dea603839a96951bd95252d8d2f74c9087a"
