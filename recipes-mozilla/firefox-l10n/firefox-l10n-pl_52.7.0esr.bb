# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3dfe2b69f85164df92ebf4c5f9e5d807"
SRC_URI[sha256sum] = "58600752bb3b79b0942ee680cbd66fdf2ea5532bb53ea62182039f11b39cd255"
