# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30dcaf154e3ce390e1d65983d86c45b1"
SRC_URI[sha256sum] = "2c9658b313547ae23defe170f5338c19bb2fd290505b32f86f9687d09a4eb681"
