# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ae545955e3726f9c7028a11b4392272"
SRC_URI[sha256sum] = "c8901b71bc06e55d03276bf6e87db0b0f29e84ca213b6d613af3f0c7ca99acb3"
