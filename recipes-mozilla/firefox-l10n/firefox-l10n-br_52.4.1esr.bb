# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1114ca724bfe6f72dbcd81fffc04df6"
SRC_URI[sha256sum] = "39672e5e39f05363be3267257fcacab9cdaad8cc1d9e0695c8bfe60b998b0605"
