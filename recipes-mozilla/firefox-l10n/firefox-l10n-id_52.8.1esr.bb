# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ba240071b3449c208460439ff6538560"
SRC_URI[sha256sum] = "16232e27f3401f0b0f32140a1df10789552de350075ec805e3fd25851d302242"
