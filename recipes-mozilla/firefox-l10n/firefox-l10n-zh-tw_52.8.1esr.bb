# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4594cd26f4f7b2d3ad3e62982258d86"
SRC_URI[sha256sum] = "64d83824bce780a32107a7f4886a40305e1abccecf229431722426244ce72dc5"
