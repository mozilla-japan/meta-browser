# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "454baa5e25c0c022ab2586ecd8c0e707"
SRC_URI[sha256sum] = "af1c46ce12cced81d0d16f124805250a64b8ea4cfb8b2c50b56b25710c591d78"
