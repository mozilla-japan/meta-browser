# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "75ad2426245d7bb3f808d1a4ad978622"
SRC_URI[sha256sum] = "46099c26087d96dc0533c6f93501d4202be5e32edf13f2abf3e45d06ab33e58d"
