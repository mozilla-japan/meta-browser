# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f04797694ca740a99b7527129a8fb263"
SRC_URI[sha256sum] = "3989d621b48234ba3205d533050c0409a602bb345f901057811729202e093a63"
