# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90797cd755749a5467836701f56766c9"
SRC_URI[sha256sum] = "e8cd8732d9aaacc4aa1aa3f85f4941fca3ffcb4a9ca008007f8700b3867ad8b6"
