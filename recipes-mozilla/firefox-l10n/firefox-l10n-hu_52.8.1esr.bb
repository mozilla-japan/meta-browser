# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f7794463cc96b363d4b347183f0c2dd"
SRC_URI[sha256sum] = "e51f468caa1788778c3bcd4129445206e5d30d950b27895c71902b59eac0e19b"
