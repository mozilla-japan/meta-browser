# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b00a3c035e42b28db60c0f8237c3fbdd"
SRC_URI[sha256sum] = "c41948a8376db432449425d5fe9c4614c0676f104d86cb205513b057db30e9a9"
