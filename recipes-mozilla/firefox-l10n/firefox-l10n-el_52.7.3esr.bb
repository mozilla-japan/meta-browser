# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "08b03a70f0521f36c7f49f1770871c25"
SRC_URI[sha256sum] = "51e1644dd51bb05f289096a476d9b1f67d5bbec937ae6555bcc8d3c47cb8b270"
