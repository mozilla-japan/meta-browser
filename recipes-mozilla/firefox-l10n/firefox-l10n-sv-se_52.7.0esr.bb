# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0ad914d361a2b8229514f3cc7ea75958"
SRC_URI[sha256sum] = "b8a736da71226612ea69b8f72c87a36e8b486889280aa3940e1f676a839af121"
