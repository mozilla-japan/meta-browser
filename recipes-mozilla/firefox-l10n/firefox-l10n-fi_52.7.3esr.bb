# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0d6c85f0bf4f09dd7f670fe700593ea1"
SRC_URI[sha256sum] = "490738101d4040c8afd214a3736e94a49936b0c184e9c65cdfd6599d1fdc38bb"
