# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c83db6b98967a2e6e01093c490c1d7d"
SRC_URI[sha256sum] = "9589fe155880559c82ef6ea24c8ca021912eee157b52be0a9cdb2b88ba842770"
