# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00f4554e7045b37c843e81e8ec0aba87"
SRC_URI[sha256sum] = "515ba6d10a0b6f4cf569cf62d981f54f332b10fc493ae27d4f5d74921ab2a835"
