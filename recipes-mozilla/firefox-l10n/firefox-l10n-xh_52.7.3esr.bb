# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ef2872620ca9418045de244ec558b766"
SRC_URI[sha256sum] = "3b8d3c645bbf11b61bbec17142de7cd6c36f8ac72858cce30f1b1189cabe449c"
