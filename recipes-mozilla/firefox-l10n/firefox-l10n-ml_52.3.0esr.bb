# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a6e863304523560c954ab07fce8620ca"
SRC_URI[sha256sum] = "e62c41c31010b7b07bee966fd54c944c81ef4a10aad7d56e5951dbed2325de45"
