# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52d6f5ef7b7f07d8fb27136a0e9a372f"
SRC_URI[sha256sum] = "8c980a19fb60acb8974e9dc2bce0967d770faafd4e3607e7f331925394438e65"
