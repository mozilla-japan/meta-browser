# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a726608c8e8e2840e7647a1b51067e7"
SRC_URI[sha256sum] = "22dccd4f47a072cfe349ace26423bf7b95492ef731fa50a11f989d2c537aac3e"
