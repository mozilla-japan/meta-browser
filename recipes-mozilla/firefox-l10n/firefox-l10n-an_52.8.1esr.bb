# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8b3216d3e7695e675b90d35a8ab2466"
SRC_URI[sha256sum] = "0811504b05656977f29fa260d75b523fbe3535c7928238dbb96b6acf4f963a18"
