# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f15903b7c590c030d0720c551ccb5a7b"
SRC_URI[sha256sum] = "4a341ccb1e270e844907b531cebbeefef7fe62bc3b5456d69b9481af0b76e561"
