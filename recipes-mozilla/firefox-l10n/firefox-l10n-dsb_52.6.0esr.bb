# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7017cd8e84275f457bc371a8da7bb8b"
SRC_URI[sha256sum] = "fe94c29278e0bcbb0fd4cac5585876e776638a47481ee254383f1002abe9dcaa"
