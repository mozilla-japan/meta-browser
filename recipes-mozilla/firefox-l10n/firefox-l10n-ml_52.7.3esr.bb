# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cda732687ddedea8fad0f25110af7fc7"
SRC_URI[sha256sum] = "fdf98a10ad5eafc52a6b71167dffdcc1af2fe89a1d966786d477f48d62a0cacf"
