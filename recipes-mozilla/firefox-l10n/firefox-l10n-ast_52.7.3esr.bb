# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc49e985d7185a8c8ba43898a04a491e"
SRC_URI[sha256sum] = "cdc997192d4a0bb24a182d24405e59191e262fdff4edbe9f0b74b065bab6c87c"
