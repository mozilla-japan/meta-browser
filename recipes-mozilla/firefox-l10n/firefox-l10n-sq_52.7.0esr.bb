# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c8456011778410a807cba1a84bbfda58"
SRC_URI[sha256sum] = "4ec07d85dc5b5e840ed055847f707526f0a2f1ff090e0786ac9be1deb34d6ab2"
