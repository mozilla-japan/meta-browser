# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bfaeedb93c95aa7f494a04064444c556"
SRC_URI[sha256sum] = "89fd98f651bfac33bc29d4eb1bf70b6b83770ffc44abce2c5b3eacbf10336747"
