# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "33decd9ab67949487dffcd70c87c60a0"
SRC_URI[sha256sum] = "853783790923104f333c5f98f4fc9c79a30a45cd95b103863c3437689e8810e7"
