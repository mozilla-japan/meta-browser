# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4d2b1123488ef09c25c1a8cfcfd1a050"
SRC_URI[sha256sum] = "444b43c2ec7dfd829db2b5380ad848bf2bb0ed63711dc18c5ffd7692bc088a73"
