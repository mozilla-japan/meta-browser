# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7d624802a178d10baf23b88e28eea265"
SRC_URI[sha256sum] = "6087abf371be4fefdcf9855540d7d08985b573cc66e731ca7b73a2d3daa7a6a7"
