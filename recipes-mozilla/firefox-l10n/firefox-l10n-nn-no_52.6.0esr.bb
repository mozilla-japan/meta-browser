# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ac717f19fccef9379333c7ab9406a97"
SRC_URI[sha256sum] = "723e65dd29e128d4ecdfd7deed0e2c2adc3422ced264c60d080d251d32027d59"
