# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5abd10b1cb9db3b2e0409028c6fe7712"
SRC_URI[sha256sum] = "e461a644fd83f460661a3b9cfbf297766087bd969865525764f4297a254b513d"
