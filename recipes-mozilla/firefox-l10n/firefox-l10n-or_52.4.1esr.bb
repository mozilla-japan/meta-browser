# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8e633189efe37e737ce7e1c0155649a"
SRC_URI[sha256sum] = "77b98727e1bd21e4a0abb6ab6dfa6a72943a8f631f975b8b37f445fa8890ca2d"
