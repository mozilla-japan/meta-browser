# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d01883bc7242bb9ddebba5b1ec4f1727"
SRC_URI[sha256sum] = "a76e954b212330d2af494ed61da7f97779db9d3ea1753e82ee5eb04eea9c74d6"
