# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af8e341d71a4775e1a227c75edaef400"
SRC_URI[sha256sum] = "ffe9c253de049981753a1bb5f29d8f1f8f5ce958d727de19d152e3c0433f8c05"
