# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a65a28191ef4af82f3ea96f4a02d8c47"
SRC_URI[sha256sum] = "a250553eb68dae9856a3d642b02a34d9ec4b08d8c95c468a22bafab5d28cb927"
