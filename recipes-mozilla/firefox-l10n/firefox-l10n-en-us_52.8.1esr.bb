# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1692747fb4ec72f1538586237c426c14"
SRC_URI[sha256sum] = "52eff45deaed0c3f4702b7c38c95ad06630387725bad3a0f4656759475748115"
