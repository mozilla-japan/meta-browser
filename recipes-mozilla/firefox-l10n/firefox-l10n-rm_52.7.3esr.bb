# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67bf9bb3cf8017753ba60ca8297e282d"
SRC_URI[sha256sum] = "455964c20957ffc4cabc43226c7216362163f716cc8e3d2632f832fc0c770da2"
