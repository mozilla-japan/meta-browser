# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "20204022f8f2511744c38cd42c61ef7b"
SRC_URI[sha256sum] = "7b8dea5cc6dd99af8b263ae44d4f9456036200f665d76f8f2f263f2e51aa0c8b"
