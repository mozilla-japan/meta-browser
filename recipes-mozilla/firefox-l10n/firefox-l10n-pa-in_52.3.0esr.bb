# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b5338d3175d7b10bf7692896b86ee114"
SRC_URI[sha256sum] = "4c116bc2534cfe7828408e007e97ee10f4ce676d07c1788383a2a08ac6d970cb"
