# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4dc9ada1bbad8be03bd33734c7068408"
SRC_URI[sha256sum] = "7d379b01e95b7cae3e3cf02f17f4d84844cc563052ef38e5df0a2a51c3d0f238"
