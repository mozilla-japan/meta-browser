# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6715100cfb20532f792a739c215dd2f0"
SRC_URI[sha256sum] = "ad2df766b51aefdb23f846cabfa02d09ce48746497134cf4306dc9a1cbb2e1f0"
