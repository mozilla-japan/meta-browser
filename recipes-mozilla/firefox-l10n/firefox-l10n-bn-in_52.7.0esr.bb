# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "798848261e270d5598a7c877c04651e4"
SRC_URI[sha256sum] = "a0764c62b042decece0ec4017837b199c53714f2c707f289e55d2e9f37c6e69e"
