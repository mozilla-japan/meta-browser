# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92d4faa200613a26b05d70dc4eb503fe"
SRC_URI[sha256sum] = "0247e0acbb439ae7903b40211d4b99d442e5dcc7fedbe200d790df8adb65eb3d"
