# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f7361302f7ebd43fea39822cf797ad3"
SRC_URI[sha256sum] = "8fbceed4ae372bd4cdd2082ff61f5cd3f9b1405ef22cc0ac5dbffd6f88f1e38a"
