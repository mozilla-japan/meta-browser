# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f9f878003019abe6038b60a2244b80a3"
SRC_URI[sha256sum] = "a113fed1eb6a13624d1e106164cd1cf39af4c9338eb43958838c59139cf67b27"
