# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0de300a6bc2f559396e622bab0e338a8"
SRC_URI[sha256sum] = "70c66d11df787d09c7c56f67cb33f4b986463a98bf2cb985ac3be05198050238"
