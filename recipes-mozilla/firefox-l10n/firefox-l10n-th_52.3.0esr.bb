# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2c1a986621726cc8bcfd3037cf77f9c"
SRC_URI[sha256sum] = "bdc05f6b3463c6f79393ce2fb224d49aa4077087604cf29429aa44c8f50bb4bd"
