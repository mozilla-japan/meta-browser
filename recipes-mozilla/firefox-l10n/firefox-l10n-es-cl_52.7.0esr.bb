# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f96c208a965603c29a5c09b8d1b466d2"
SRC_URI[sha256sum] = "cb6c4476c39a2c969bdcbac08d8ffcd2517707d581d5244bd4af1fbe245d016a"
