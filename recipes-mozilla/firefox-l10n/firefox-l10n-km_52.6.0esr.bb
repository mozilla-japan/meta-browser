# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70c47d169f9a20d7d83ccc585bdccbbf"
SRC_URI[sha256sum] = "9648d1e49d360c7e8a124708a5f98c22880fcc42e5efa2f5f5676099e3f68173"
