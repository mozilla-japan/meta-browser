# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "70b07eb0b126c1209a65f6df39d74139"
SRC_URI[sha256sum] = "1dfb325255088041b17932db0da0075e26ebeae304eaeae6b2b98d95b06d4495"
