# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "663ab4d11123f9048ee90cc8ed3ed42a"
SRC_URI[sha256sum] = "33286c214ca1ac03236b41e6ff67c58b2500dafd25ec2ca82ec35df0f3cdeacc"
