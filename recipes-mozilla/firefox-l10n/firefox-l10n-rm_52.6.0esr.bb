# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d7b17a542a385f1f12634d67c58f0ec7"
SRC_URI[sha256sum] = "29278498eff349a13a9ed87ad654bb46c36a57e4587cc2890607ead0c1fae94f"
