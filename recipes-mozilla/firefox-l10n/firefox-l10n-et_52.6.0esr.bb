# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a27793bdd9815d0e67a15c601c7764ca"
SRC_URI[sha256sum] = "c0f6680a14b29d2127462c576b630048bf20df3d328b00e149f2452e7e17c619"
