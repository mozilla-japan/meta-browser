# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "64f6f6329d6581ca8846ed65dff42a2c"
SRC_URI[sha256sum] = "d67896d54365c7a3eac5b4c9c3e3ff59804f31cdeedead9348f32834cb0f7caf"
