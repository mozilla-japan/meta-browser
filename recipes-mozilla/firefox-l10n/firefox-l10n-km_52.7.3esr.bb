# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f7ae06960bb7f7ac276bd3ca4d920bd"
SRC_URI[sha256sum] = "433db2b6c69a45dd487c11757c34e3149cd3b353946c896d034956313e8fde3d"
