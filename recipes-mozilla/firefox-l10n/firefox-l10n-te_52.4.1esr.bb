# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc5502945390784ff6d038bf74329ad9"
SRC_URI[sha256sum] = "a6bc0cdc899eaa28d7aaad2e75e315641532b82b7b3c4c78084405d8c7671b12"
