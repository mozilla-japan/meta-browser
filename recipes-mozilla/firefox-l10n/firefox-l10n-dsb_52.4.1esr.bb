# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c08c6108a349ed2d3367ab50a193e6fa"
SRC_URI[sha256sum] = "9620f5443792ffed84d7c0b2e9bbc4f3a92c68869f8f43c3661642eb083392c4"
