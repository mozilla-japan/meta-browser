# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "941935c22f2f7aec9e0e922ae540603c"
SRC_URI[sha256sum] = "3833e83d4fd1f77fb23a6095d4dfc0a903ebc5618a67461c10e2ab27d5d63941"
