# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf5b89dc9917d9730de71e3e0165ee4d"
SRC_URI[sha256sum] = "bbcf3c7f17f6a3d4819364e45568b4d7f03d513f45a3c536fa51219c202c4da7"
