# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3c7f6cb8d4def11c2bada61b7603c97f"
SRC_URI[sha256sum] = "3ac47a89a0b4035b5a33209b6e66975af0e201f3634b41c264998b94533af69c"
