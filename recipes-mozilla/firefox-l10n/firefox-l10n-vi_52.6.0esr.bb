# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4325f5e6bf06452fc4242b4f01293ca2"
SRC_URI[sha256sum] = "e9b1354846a186f691c08b3b6b01d2c6a9d15280a63ff43c4b56da14ea495f89"
