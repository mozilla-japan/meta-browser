# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36bf04d23f9ef41c1e4c5c874f7db486"
SRC_URI[sha256sum] = "1a8c00470270e574b0dbc29de383a3f130d3a505d204c3e28138394558b49c94"
