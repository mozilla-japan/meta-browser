# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "11502d15e065c0f5ce97d694a66ede96"
SRC_URI[sha256sum] = "09da219a8c38d71a9a1a83ca8282779d28542b25493a766b2d2b077994ba3e65"
