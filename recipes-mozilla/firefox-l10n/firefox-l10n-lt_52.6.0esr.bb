# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1d5648f9cf46856031a947032e360262"
SRC_URI[sha256sum] = "cfaca90ff40f5874a4720b01acc74218709400c1a3ec6baf794fc30e70967ced"
