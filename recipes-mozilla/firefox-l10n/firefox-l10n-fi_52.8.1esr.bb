# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "97a8724e9ab9c7ba374bcd43a9a3b664"
SRC_URI[sha256sum] = "814eabae8b31084dbf5c4a4c0f85e59daaaf61447714d799f5a9dd8cce5d8761"
