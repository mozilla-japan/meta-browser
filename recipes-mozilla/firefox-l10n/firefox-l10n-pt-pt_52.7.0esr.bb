# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d1905bdca6918d7f96700e14986fa601"
SRC_URI[sha256sum] = "5ddc539da003e9967b0777f38799f488dea7338daece590924efde3f353cc551"
