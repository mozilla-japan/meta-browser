# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8bb2e252224225712f900318477c4d86"
SRC_URI[sha256sum] = "fd20e675130a0a585d91dce4a5106c80ae6e7bf909824d2f941b9a0b38bd6b4b"
