# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "96e86220e66de0aad6ed6595ce617fe1"
SRC_URI[sha256sum] = "846bb42fe8354d852881bb4218f55fe4f8a47551458d15b5978105c4bb7c0508"
