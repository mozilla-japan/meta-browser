# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7462cbd043ff8784e60a64928693b9b3"
SRC_URI[sha256sum] = "a708b3395913ad9a0a45659be578822a4211de8b381d851cf2404c07b8703a80"
