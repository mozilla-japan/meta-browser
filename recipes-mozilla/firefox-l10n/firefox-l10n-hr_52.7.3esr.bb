# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8c34afae0e187acf883d31a463aac05"
SRC_URI[sha256sum] = "be72a711fc4c6621499ae00e16e9c9110857c47f81fa44f8ef1ba33673ec02cd"
