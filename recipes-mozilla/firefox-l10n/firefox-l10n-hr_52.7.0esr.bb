# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "63702b93bbbb30646bcb596743184f6b"
SRC_URI[sha256sum] = "7aa0393aea0c1f699964f37bef2b1fb00cc95c9302748db18e18cd037b74b35c"
