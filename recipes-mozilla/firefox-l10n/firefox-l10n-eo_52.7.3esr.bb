# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c8eb472a0aff8313d3626d6d68458925"
SRC_URI[sha256sum] = "5a806a6a8031ede966ef3f6c500a8ad2d03b7188d6add425beb50336ba62bd57"
