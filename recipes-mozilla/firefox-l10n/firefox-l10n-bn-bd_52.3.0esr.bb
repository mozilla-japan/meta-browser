# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "591fb682ac7f3cd70888cfad428ccc46"
SRC_URI[sha256sum] = "397b9e0887ee70f343c3952ad1e0e9cc7656cbdedd73e059e9ca9dc6f0e1ef5c"
