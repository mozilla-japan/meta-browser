# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73daf36891a0fed44817701f3e0f4422"
SRC_URI[sha256sum] = "c8e61a24fda87f62eef775152027b31ca62431c9fe1ce3d39e296c57e72c35e4"
