# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "481c9d492c1c600c498e6f6f41614feb"
SRC_URI[sha256sum] = "ba68bfbacc3dafcf45ed876a528366d6cc332b4bd9d1ba1b48d15cc8e1f1e77a"
