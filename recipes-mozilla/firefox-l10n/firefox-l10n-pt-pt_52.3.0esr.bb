# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "53ee2312ac215a874273fc4b44d9f743"
SRC_URI[sha256sum] = "706004d4d41d4a95aa7ebcb8a414d1247f82850bca7977004e70d69c03c11d3f"
