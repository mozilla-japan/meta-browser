# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a136e244ddf6b56ef008801f346ac95c"
SRC_URI[sha256sum] = "2de89d29b86a4bc26bb0b9c2015e8c2f23eec78703f759009f39126afe77f703"
