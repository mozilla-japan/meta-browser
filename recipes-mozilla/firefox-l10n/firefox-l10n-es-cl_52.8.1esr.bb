# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5de331b7ec9348b3977210a972b4ce0d"
SRC_URI[sha256sum] = "2bc3335d68004688845d76f19de5deb40de5169704dcf0a8bef660e608b37c10"
