# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b645f8dbd661d83ec38d3b96060bb1d1"
SRC_URI[sha256sum] = "946c9f5af1d13666e055cfac4dda0a5ec7339df0cf09bf725889212cad26b159"
