# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e4bbef2b973ffbbf98556800f77d9e3b"
SRC_URI[sha256sum] = "3c7c8f9b1555f735193fa91ef7e748c2dac7f57a136b7095829204e0f889544f"
