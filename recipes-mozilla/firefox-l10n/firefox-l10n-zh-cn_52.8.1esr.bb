# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f34027cc6f42e2a4591ee4ed3f5a5f14"
SRC_URI[sha256sum] = "0f7d582a2dcd54c6c226e6c20f7dbb61636db1f1b292bf5735f4aa9004a9e803"
