# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44b3fa998f447db720fe762e232bd5aa"
SRC_URI[sha256sum] = "53b6de8f0334bd49399e308c265c92e3889776c85f07a303a81cad944a5d7363"
