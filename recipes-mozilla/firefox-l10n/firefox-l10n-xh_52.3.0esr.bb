# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f0a82b2c3b29ca32fd25a08cc961b5dd"
SRC_URI[sha256sum] = "f47466dc94ebcd3e60b01aaf8cfae1db7acd6faa7c49c7b05fb8c864f97a06f9"
