# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b8817f4ad8425f976c9a1fe0024185f"
SRC_URI[sha256sum] = "f7a0e1fb273ad4a9c924bafb4ffe23ad4346d7399cd9060488478523df952747"
