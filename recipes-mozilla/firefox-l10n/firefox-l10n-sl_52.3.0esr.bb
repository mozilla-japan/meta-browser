# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2f6cd409fa871f527c87e3512cae44ec"
SRC_URI[sha256sum] = "4de94b52639ccafeaf69cc4c036b03303bcc22f5a7a8f40de2f9376ace18694d"
