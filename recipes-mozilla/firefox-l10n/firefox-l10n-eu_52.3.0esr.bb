# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f8e5f33f91a091f663babe8b5263f4a9"
SRC_URI[sha256sum] = "8a3dbf459aa5e5bcffb69f4c42d27c940d08e6fb14293c2375f1d7352ae506df"
