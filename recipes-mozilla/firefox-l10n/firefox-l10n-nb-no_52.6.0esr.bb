# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "15a535fc67f5da1f93bd5050ad5855d8"
SRC_URI[sha256sum] = "36ec79153da3d578e918a519ca026cdd0261c93aa3ca642ab70a24390ba7d92f"
