# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "945424d0fc157dbb984780048572b7f3"
SRC_URI[sha256sum] = "739da889c80ef06f83ef2783002adeb719e44a41855d9c81c45ec6d35ecd6254"
