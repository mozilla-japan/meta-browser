# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "817d023bc4028d96935b41087131a89f"
SRC_URI[sha256sum] = "8535bf49b85c322237d1008c432e025b325364e022236ec6741b9ed6494611ed"
