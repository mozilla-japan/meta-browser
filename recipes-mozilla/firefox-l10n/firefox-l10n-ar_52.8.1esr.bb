# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad1b6d7e1f1187f8692334e460edd078"
SRC_URI[sha256sum] = "2124be48e91dcec4234c0e4a51d69b908d8498b0914a41d3eccf30358430f10b"
