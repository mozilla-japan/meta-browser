# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d227301711184c7bbe50bc0188dd849a"
SRC_URI[sha256sum] = "39260ae8188a167d5bb67ffdc2138f354e8885533ffd665aa33baa3dec272943"
