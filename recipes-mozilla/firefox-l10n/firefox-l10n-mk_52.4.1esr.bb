# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ac3825af7b40cb9583e1c1527fa98cd"
SRC_URI[sha256sum] = "9640ba0ae6e4dcf42e3e6581863142bfc43ad5f46f16eccd54e0ae61f56d0401"
