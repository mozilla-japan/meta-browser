# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3d8d8d775ed2b1140d3b8dcfaf0e2a8c"
SRC_URI[sha256sum] = "d6bdbde687f2cedbe9cf416b10d1d7ea2a6fa897836f4b9309682aeada87ca6f"
