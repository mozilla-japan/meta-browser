# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73e1a26b4035dc3580cb8ffcd3c9fbf0"
SRC_URI[sha256sum] = "6dd06ec2a05d525365406f0d1e73abfae9b8e5cd0889c7becb7baa1ab4e8540d"
