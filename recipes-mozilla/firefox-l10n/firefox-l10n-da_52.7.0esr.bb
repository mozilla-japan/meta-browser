# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7911262ab4e150c4137ca12db879384e"
SRC_URI[sha256sum] = "697951a1830da4f9c3bebccd9d403d7e34d8ec07668e100ab4ec48af34a9a7ed"
