# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "65b8bafac3bffb03232407929c1a4e2e"
SRC_URI[sha256sum] = "26146a3af71661a15840e3be2ab4000ba47fd032ead5cbe299ece45e3df6cd96"
