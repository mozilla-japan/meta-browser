# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "84160f28d0a406a5df2aa7b1e43eadab"
SRC_URI[sha256sum] = "e2dec620cd330af4b98e8d12f7651f0bb479bfb75ce62a1f2e3ffde6f23968bb"
