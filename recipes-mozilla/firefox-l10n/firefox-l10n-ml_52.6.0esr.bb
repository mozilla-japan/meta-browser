# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c81fe96cd46fcda3bdc64f316bf468c"
SRC_URI[sha256sum] = "658d49fc128bf434eb9cdb44be4c9b7a9de7accc9e0ba02b7a9d0a49359f3c87"
