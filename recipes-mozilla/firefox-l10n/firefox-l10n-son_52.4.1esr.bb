# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "da9128df66293c0bb1a5391d3fa4a651"
SRC_URI[sha256sum] = "7775025089c5ef4f449fd9e004d317082a233cc137ad387859f2e7db3245cd41"
