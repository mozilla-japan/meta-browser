# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43d49b59368c7f92a9720fa1ca0f4d7d"
SRC_URI[sha256sum] = "6bc2bd872aa51dc7fab669c17acdbf035891e6f357661bdf99897ca725750753"
