# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "31b7419a3d8ab88ed27d211977fa0c75"
SRC_URI[sha256sum] = "a5f04dcf0381246c5327e12f147eefa030a9e9a93aaa650aee17148a0e1f7a8a"
