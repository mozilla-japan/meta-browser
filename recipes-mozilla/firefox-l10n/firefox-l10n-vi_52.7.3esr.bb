# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4d59d27c808eb9dfa1d5e28b6c93faa"
SRC_URI[sha256sum] = "14ea9434595808c5ddf135fc56719e1e37e030836bd320067a8726d020afcc43"
