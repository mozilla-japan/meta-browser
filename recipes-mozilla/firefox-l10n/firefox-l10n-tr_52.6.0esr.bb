# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "671a63a6715009a93ffc3d093f83d36c"
SRC_URI[sha256sum] = "8cc36366cc33dacbb04886c94a8a1cfe4e41ccb18262f4f59a47837ef0f96c7a"
