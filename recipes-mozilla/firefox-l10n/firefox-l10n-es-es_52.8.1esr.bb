# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "24e8f9ef4e70fe9911ed40b92adcf909"
SRC_URI[sha256sum] = "321db5bad9f491f5928875830ebae1c1f6084bb0acddf4f76b3998a641f04f3d"
