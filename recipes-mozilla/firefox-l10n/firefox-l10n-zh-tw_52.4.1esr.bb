# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a5b356e8d605469d6088609615e5e854"
SRC_URI[sha256sum] = "f3f999b86070cf6a72ef98c86e0660080b9b2624db491d6391b83617c8d0c217"
