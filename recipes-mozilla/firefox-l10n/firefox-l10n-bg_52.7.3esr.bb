# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e774fd554569267c3432a5852394473d"
SRC_URI[sha256sum] = "e241a5caf34682d9a5d5f1d8965f6050139a946ca724f2ad899f0d77a8e71ade"
