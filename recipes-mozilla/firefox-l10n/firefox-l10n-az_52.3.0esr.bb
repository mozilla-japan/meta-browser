# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dbcfb8765626ee13e74ad79dd5e118a8"
SRC_URI[sha256sum] = "768244143eda032162c3daea1d2c1533b31c6a86b6d0d19ce5ec39e09a43e523"
