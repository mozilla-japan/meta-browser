# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e75d4cde3977a9d76429c01e9e7636e"
SRC_URI[sha256sum] = "43636e211378301397be9f2d7ccb274891bb68fb631df2d25b95d233082d0da9"
