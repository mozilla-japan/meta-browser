# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5d584e300e2dbf5137d02cc1b98398f"
SRC_URI[sha256sum] = "516170dfd7524de3e20fc5dcc8cb081e6e722a9977424772e4d742499b33c524"
