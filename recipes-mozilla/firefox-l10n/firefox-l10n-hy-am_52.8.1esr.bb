# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0bcb7ce547902c002b92a7632c7518af"
SRC_URI[sha256sum] = "9ee65e2fdb96517b78bc726a91db6734edb07c9119b2a7caedd7f0b7ff27edef"
