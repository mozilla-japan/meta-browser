# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81cd639472660778c66754c81d782269"
SRC_URI[sha256sum] = "ef5637d5372ea4e581b1cd6616a86760b293e837f01e6cfaba8787c77ffe5885"
