# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19b16d1242cc6ad00bf1990f6861131a"
SRC_URI[sha256sum] = "968ff5a00698ae9083031e9bab91f96e287387e36be3b806bebe016a803fdc43"
