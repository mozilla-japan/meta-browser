# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fef019f25286044c6cb01d66bfcddfac"
SRC_URI[sha256sum] = "1c292fe497913c34a188a5c8a3be1ed509b74f948a00450ac990cd8c160bb4b1"
