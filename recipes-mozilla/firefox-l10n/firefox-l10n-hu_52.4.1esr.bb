# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2c08102af38a2fe50359a5e4499409ba"
SRC_URI[sha256sum] = "c174c4b097cb2aa151f06ff795d3bae0bac09700bddafef31a336d30cb9c5a88"
