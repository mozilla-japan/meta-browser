# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b5d589856c6e6a32d33b918e700127d0"
SRC_URI[sha256sum] = "ee5592aba2a3ec9a40aa4ad5059ae110177c9929b568d780f59598f7a06017ef"
