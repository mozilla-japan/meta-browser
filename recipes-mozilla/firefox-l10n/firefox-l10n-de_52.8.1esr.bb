# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "91b0fadeebe72d53db898285bcf8177b"
SRC_URI[sha256sum] = "3f08a3e68059373f6f42540ada840550f6a10a4aeebcee013fb4c4294be0e7d7"
