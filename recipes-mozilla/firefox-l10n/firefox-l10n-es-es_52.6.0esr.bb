# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0362de20c8c8e9866cb544cf672ccacd"
SRC_URI[sha256sum] = "d4b8edfec828a74dd55b32b3a06ab25f86fed25c6ea0dd7e0b56c07807a694dd"
