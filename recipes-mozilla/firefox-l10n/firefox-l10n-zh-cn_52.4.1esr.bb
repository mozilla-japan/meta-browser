# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "97de4837b99d6de00d05d8fde524628f"
SRC_URI[sha256sum] = "ed56ed0cfb27278ae6e1ab9519cdb38f3012f26a83db20fca348687fc75744b6"
