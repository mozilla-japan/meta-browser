# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c77c2297a5d340e81ba16772f863bb5"
SRC_URI[sha256sum] = "2ef4009632b74fca6615b56d7416f6af9d22584c4ee35031162d3ac9ffa097dc"
