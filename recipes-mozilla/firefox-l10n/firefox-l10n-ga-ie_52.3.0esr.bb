# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5536d8ca1c4ef9c021010ba7bdcc3a43"
SRC_URI[sha256sum] = "7de28f84b6b75f2d20e45d4f47bdc232c192c33d95c6267f05a9fd4057bc477b"
