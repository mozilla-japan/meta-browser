# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "80a7b44cb650095016ef7fca61fdbf3f"
SRC_URI[sha256sum] = "53527f4bd28e0f3c71a2d04b3799ccdd7f64d2887119e99c5a040b820944c0f0"
