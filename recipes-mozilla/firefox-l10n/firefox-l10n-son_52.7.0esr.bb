# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "844395d5c89a2657f46a941dce5e93bf"
SRC_URI[sha256sum] = "80841d5b36b7111754d885a5952860394be2c0158cbdae70b3ecad725926db51"
