# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f18f370ee10b8d6ad0e1085046b2ee6"
SRC_URI[sha256sum] = "784248bc17afaae43f5e95932f160cb050df4faa7049ea85446f82815d6a9e45"
