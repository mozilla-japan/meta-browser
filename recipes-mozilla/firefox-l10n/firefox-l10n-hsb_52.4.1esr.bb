# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68da89ad0708c88050c5195e398ae3cc"
SRC_URI[sha256sum] = "a1498da7130bc5396b4d0e8f53d3cb1814a9f5f219bdc471ad315dd2610fb5e3"
