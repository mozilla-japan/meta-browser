# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5cc4f22e49a0d5d6ca3fa8402780c3f1"
SRC_URI[sha256sum] = "3270fe9b2bcca9e06d2eb60387e90e2107d9cc9ace751d4676e1cbb5b5076c84"
