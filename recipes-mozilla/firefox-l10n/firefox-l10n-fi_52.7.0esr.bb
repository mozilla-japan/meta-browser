# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2eef93d2d7d7a391d213d87879334df4"
SRC_URI[sha256sum] = "b26e5fe9b8519ef7a759a53a2a5fcaaf0c4c322481f26266013bf169db972f58"
