# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1035a99813cee6b0ebe85461c0d5063"
SRC_URI[sha256sum] = "35e5d402e48d3df920d47bdb4c6e818a0bf7ff3fbe74decf00c5a241cf309b37"
