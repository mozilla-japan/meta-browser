# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "15f8d5aac91f96af5edc8278918e7a9c"
SRC_URI[sha256sum] = "bef2c59b89bbcbf6ab00e6738c44b1bad29f4110e49a7d975dbd974826ae7451"
