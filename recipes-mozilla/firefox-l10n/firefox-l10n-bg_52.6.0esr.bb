# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ea0771fe4f1a58f8c38b04f569e5e3a5"
SRC_URI[sha256sum] = "6c50be8f79871cb335054566ea81cadce6fc865e9db2fb6d9dc0f3b65d7b1505"
