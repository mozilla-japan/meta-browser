# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "effe903219e3929718e7c45ee6be2257"
SRC_URI[sha256sum] = "8f1254aac3e2332570130762e4baab6f718374bc48626efd82117d9f254148f8"
