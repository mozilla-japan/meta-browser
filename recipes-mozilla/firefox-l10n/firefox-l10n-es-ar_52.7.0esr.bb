# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "43943a670408a3276c8d2edd94c7eb03"
SRC_URI[sha256sum] = "8ef85f85ef064d889937392e7428781972ca30c8c9b92ac4aaf4bb6448ca64df"
