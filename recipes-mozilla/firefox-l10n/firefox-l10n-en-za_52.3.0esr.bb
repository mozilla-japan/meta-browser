# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db39d2b819192396778060f7e6217a16"
SRC_URI[sha256sum] = "f8270ae9412b220fb7d57a6afb6d29890e8d8a17f42898e206b96c5060f69cc4"
