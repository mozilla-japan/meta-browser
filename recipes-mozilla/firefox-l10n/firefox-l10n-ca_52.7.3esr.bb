# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6d8743797088d9718747843b9d5fcd68"
SRC_URI[sha256sum] = "621f013798a94a78c1c91916fd1bae306f9822c71df291838d8ca249c6c6671f"
