# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0574f6487ddce4f38a5d24386cb80846"
SRC_URI[sha256sum] = "c2c78c21c5215478501a0fa57e7b903568609b17dc2c6a80ffe98ff76cb4a527"
