# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81de3b0c9d574c06cf6d420a93d2b588"
SRC_URI[sha256sum] = "8b91db806b46c6769f6b1388f9c904960a55844961d7b2c3be4d4a0598ef45fd"
