# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd5b70f12758fd3378c9be274f355bb6"
SRC_URI[sha256sum] = "42f3c388e6b25b2c3af92a881c980476e53d0e4f05cfa0721de2def3b7667efa"
