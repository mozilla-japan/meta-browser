# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d70bf72de7834e077a8dd822eac6608b"
SRC_URI[sha256sum] = "99656c6cda3f7e5f55e26203422070ff0d4b42b3886586de6a8ac42b85ee8049"
