# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "73beaf7a8b3ac30b8f52d5179b689145"
SRC_URI[sha256sum] = "fdf3108e0af60562c0faa66cd1949a64597431251ea415bc66f478e282804c24"
