# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "aa7cddac1cd98cc001010614c6873cf3"
SRC_URI[sha256sum] = "acd161a5ed544dda0041bd2929a6dbf7f7157983d2eeac24351b644eb5af34a5"
