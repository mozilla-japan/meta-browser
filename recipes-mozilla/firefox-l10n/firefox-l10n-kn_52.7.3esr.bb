# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bbc8522e357cfb5d401c4ddf08a604d5"
SRC_URI[sha256sum] = "dd829fdaa689a9a4805aa5e1ef457bb08ebc765ff5396ff21cbe91b3fdeb19cf"
