# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "291e99019061f326e6b2e362063036ad"
SRC_URI[sha256sum] = "80fa3816367f75fa97ab7442aba20751df45875851a5bf6e4081bbf9c1da4f7f"
