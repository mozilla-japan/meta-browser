# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f35e9418e74e2a37594b863243e3fb83"
SRC_URI[sha256sum] = "c9f4d2a9d96488c4396e5d8562f7479f77d53a3ae35e3e267d08b8ec086d11cb"
