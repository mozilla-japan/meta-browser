# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf58d278fae7b973cfe5a38dd2493b16"
SRC_URI[sha256sum] = "b319fc11354f35ba42d1bb8c96e9fa706238c05f520ee44159f7ebdfaf67bf2a"
