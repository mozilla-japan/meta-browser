# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5a744e626450b4baa14f00a500ded51a"
SRC_URI[sha256sum] = "d1d03908d854fba978ff52898e8b7b1a493e27d251397c1ce478be76eba1880d"
