# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "14fc357d44880e3367e20353749cf052"
SRC_URI[sha256sum] = "58869f0c6951bc01a02c66f9d1caf939e0577f21de1e13d978c708026ec68c45"
