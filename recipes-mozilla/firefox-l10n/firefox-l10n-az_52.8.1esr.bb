# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae5fe56f8b6be473e65b425833c79f5a"
SRC_URI[sha256sum] = "283a67e5bdd93b2dca0cf85ab9605bfa69d992329fb526d6cb745fc9c7953cb3"
