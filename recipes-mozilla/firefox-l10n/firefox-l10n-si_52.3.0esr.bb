# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a7598be88411010b8ad5d7c5033e7b73"
SRC_URI[sha256sum] = "3bbb55aad8181ab949623d2aeae7a91f1ad0228bd1a6415ab674d717fbb3ed87"
