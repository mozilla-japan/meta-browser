# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5822ca6145bbb8f7c82b65ca730b679"
SRC_URI[sha256sum] = "1349c445ca630a4e816198203b985dc0add0d8d9be7e8041e4aa7c70c2eb7a4e"
