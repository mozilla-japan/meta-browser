# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0a191a2e6679045ad5b372b08b70c886"
SRC_URI[sha256sum] = "267dd3d9070915c1b949982f64d5f727f49faa0c32c4a06b0b5ac0efd9239f16"
