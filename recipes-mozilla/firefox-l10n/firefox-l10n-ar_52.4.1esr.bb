# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "382b80eef4c250ade91200978db21d8e"
SRC_URI[sha256sum] = "fab513284589342cc9d85be59956a07296b1ac07824648b2c6c1a48e463bed44"
