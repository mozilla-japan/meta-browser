# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b2fe93220263f015bf28b1c7da3768a"
SRC_URI[sha256sum] = "e72d2816b03299b1194c2a88d1ed582d1ee159ed1202ed00bc1a062a6e1deef8"
