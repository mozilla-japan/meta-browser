# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "06117ab3944d0254aee781b58e266288"
SRC_URI[sha256sum] = "d70ddac75d37e654dac89bc1c0c4ff963bfbc8743d552efc08e663df5c07702b"
