# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1a869dcf5abeae253df09ecfc7452d5b"
SRC_URI[sha256sum] = "34b66db16e269c1837a0cad13980163c16e86a408c8c02197c68dc98986fa1fe"
