# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ef67779e6bed359aa5b5083b87bea18"
SRC_URI[sha256sum] = "3169a8bc2bb3665edff1e6704f86a0cf253f7e5a2a501eebb0380526bc93181c"
