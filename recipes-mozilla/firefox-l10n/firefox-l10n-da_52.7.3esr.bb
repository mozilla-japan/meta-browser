# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0932b7a80963822c963375df3bb2dced"
SRC_URI[sha256sum] = "5433fdae88096b18912201a0808f1e3138359a0f3c07478e0746167bcdc8d955"
