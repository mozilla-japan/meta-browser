# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e00b860d1a79831da7372e28f07a57cc"
SRC_URI[sha256sum] = "33c79fcf432a8be5b5f77bb07313cdb07514270bad90b6de31e4d21c4891ae81"
