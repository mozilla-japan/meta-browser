# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6b5dff490b1ed0d052c538fe305b71c1"
SRC_URI[sha256sum] = "400e9726e6b2576bc86bd6af68163e68700ef74c991c54b0d8a4525817857f74"
