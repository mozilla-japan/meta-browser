# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92f43fe361014405f47984cac0343444"
SRC_URI[sha256sum] = "497fc3d8804b7c08d5a98108167a409f4f6cb48f79dd1b218fa229ad027e050f"
