# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f2cdfd2af251b389b79fc49503e7774a"
SRC_URI[sha256sum] = "c535c11c856aab036b8a827fd0eb02283f4397807c10330c021b7fd5cdaaad9a"
