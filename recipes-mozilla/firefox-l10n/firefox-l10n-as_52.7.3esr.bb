# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8609f23f7ab41592490f960441f37685"
SRC_URI[sha256sum] = "f1770f3f31f68159ca2d350de34f15c2e8aa7940b32ca77fd137c56035144866"
