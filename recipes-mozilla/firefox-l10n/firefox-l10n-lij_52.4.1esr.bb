# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a326ca7dd85eedcacfd18010bfd737f9"
SRC_URI[sha256sum] = "82803d9f396c75450945d749310088aa27129f7379d22adcd6382fe1797750c3"
