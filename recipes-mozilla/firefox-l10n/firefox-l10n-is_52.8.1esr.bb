# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5e8b69f659adfc965a0c2fb8dd981165"
SRC_URI[sha256sum] = "c424af7cde25bb2e85beda699fd795e791c06591ee12083fc89b3906d5cb5e78"
