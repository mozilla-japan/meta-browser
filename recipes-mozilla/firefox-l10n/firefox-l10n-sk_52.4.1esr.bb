# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c5bd8ca20bd515e86b7a25a19ac8cae8"
SRC_URI[sha256sum] = "be5c59d45f7cda81bf1e30123ac5e6c1533ad8e4e905004c2b91e6582e6b31e7"
