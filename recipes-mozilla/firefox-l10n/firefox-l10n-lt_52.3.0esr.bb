# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "004f23bd05e83a41be2ce380a6b9c5f0"
SRC_URI[sha256sum] = "06251c9170717780d2d0ef5591e36f7956780a4944be54abd63b6a66a5733c36"
