# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a410ab6fbf755f7875e48e164c81649b"
SRC_URI[sha256sum] = "07eb181ee7d6f2760d9f46d2c7f60943128779e8aab90225d988269c6fb64b1d"
