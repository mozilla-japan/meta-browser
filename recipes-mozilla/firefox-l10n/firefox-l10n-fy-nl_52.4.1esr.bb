# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c8730b29553c50b497fce3c76ba360a1"
SRC_URI[sha256sum] = "b33870e7adb1afb8b5445c78732891e2b66f886112e3aefddea8a329f5c3a7f8"
