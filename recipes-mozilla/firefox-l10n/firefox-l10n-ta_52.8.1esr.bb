# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5e35853f2531be593f69cb7ae77bd09"
SRC_URI[sha256sum] = "833bbc95cdb6ee9dcc47c5dfcd769dc81fe298da8933261ba7808e69825c2e5f"
