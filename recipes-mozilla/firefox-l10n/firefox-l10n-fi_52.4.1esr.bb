# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4bfe0cf26f70c4c9ee679bcb700e4c70"
SRC_URI[sha256sum] = "db340cfa72d7f6d0fd8dd9319bf99a9780ed0376ef04c15147ce59bab889ff05"
