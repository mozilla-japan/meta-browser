# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f961c98697f3fb6ae9e15616c5a12e26"
SRC_URI[sha256sum] = "55725b6535315629c17bacf8da3589fd4a2003f169380ba686559ac7f3bab5ad"
