# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b873bd227343c8bc14b0632a57feb0fe"
SRC_URI[sha256sum] = "263153b23d4f2f5c255102558c646a114aec6a339d5399343845fedfbb0e06b8"
