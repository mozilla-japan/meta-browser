# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8b1179acb4d9eba2611a684dc2b0b57"
SRC_URI[sha256sum] = "b852712ea859a6f919c6e562739347c2cca4f561efed755d7281509b09d73a60"
