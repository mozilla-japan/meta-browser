# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "20e9968524c519c7ba72236e9471fb2a"
SRC_URI[sha256sum] = "ac65e91404a14a665bef90a8543174590abc60a27ac064a448155054c596306d"
