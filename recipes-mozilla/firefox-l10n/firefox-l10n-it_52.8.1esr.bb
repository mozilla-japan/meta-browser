# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b95bef8beb0af5a4eacc4dab2ee7875e"
SRC_URI[sha256sum] = "378c435ae58b915e8de92b4957cb9bb7a8ce05c61978477561da483facc099a1"
