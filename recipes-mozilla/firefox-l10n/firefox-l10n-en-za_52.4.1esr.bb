# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "231f9b5f486baf451a5b5dcd6301bdc9"
SRC_URI[sha256sum] = "762845a9ca4867860686dfe0473aeb120ed0bf386bf3754f2129ba0032f97521"
