# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44ba3cc989a3c479ccd2f130a73c42ed"
SRC_URI[sha256sum] = "238911629564181d96b43b9561d44bc0c7b984c59da69b05efb6793b03fcaa32"
