# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc7c3ca42a4a841ce6146897aaef2db3"
SRC_URI[sha256sum] = "175b3feda8cba01d15f0f643bc36eb5ec68f9f87db2eca121266e23432f5355a"
