# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "344f1f6ed6ed11bbcb98359cfaa64208"
SRC_URI[sha256sum] = "38f61fabcc54acccbd417944a144449a1aac70253054d0c682afdc5dbb3cb38d"
