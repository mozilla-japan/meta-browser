# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a394b699ba3b0874c0a9bc7b6bcfa839"
SRC_URI[sha256sum] = "c27ef252c49c33ef4231e32d6093605f7b206b4282609e4e789d7e3a79a0fc69"
