# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "231518277e2bb92a0ad609fe36a9d962"
SRC_URI[sha256sum] = "f327833a3167678f10aaf2ca371756a81d2d9d6b6f49fefdef506fd60ef2d8bc"
