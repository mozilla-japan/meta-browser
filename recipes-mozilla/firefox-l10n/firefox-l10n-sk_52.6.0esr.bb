# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f27906a240486fb7384db94785ffafd"
SRC_URI[sha256sum] = "67042291540fae91aaf5859ee09b480299980a12e6ade769d521a160b05f4ee3"
