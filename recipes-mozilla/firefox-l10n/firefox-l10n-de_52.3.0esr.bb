# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fcacde445dc6111eb941f29ac70247db"
SRC_URI[sha256sum] = "d6b299afd7c1ffbc1ea998a44700dcbd8d0903c5a5257e24b8a7559f2d0dd9f1"
