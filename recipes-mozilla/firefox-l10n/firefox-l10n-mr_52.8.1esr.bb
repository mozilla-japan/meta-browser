# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cce04d6926167345c82e663d07ae2c59"
SRC_URI[sha256sum] = "d2b5e7c07a6a1f8ef103be144a40dcccf127bd02a0ecc83f2d8e7237dd4b4481"
