# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "127115b812a6c6fe302bd15733772f47"
SRC_URI[sha256sum] = "db6a0b8286880d6bf85cd3a0953963c584c78690cf48650a7094cd48ee1781e8"
