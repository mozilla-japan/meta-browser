# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8af207b40e1be92929741c83f946dfc4"
SRC_URI[sha256sum] = "10b39ebe7d0078e5f9eba2d08ae97e9c71c1f86c04ca78b0cf9a5da8d596172e"
