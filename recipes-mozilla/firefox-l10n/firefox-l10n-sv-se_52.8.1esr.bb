# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62484d1bfa2e66556318be59375e63ff"
SRC_URI[sha256sum] = "bd2244bc00bfc38fec5eb9ed04e597dea391a6519942451ec2a4023504359a16"
