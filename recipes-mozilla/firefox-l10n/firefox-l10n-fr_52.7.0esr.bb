# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e00b5d19e1049914a4ac3ac35bdda6e1"
SRC_URI[sha256sum] = "7dc7fb9ef5b9a4d0fc80a18df09f795720305c0aad44bc7364cc0d6b36762a22"
