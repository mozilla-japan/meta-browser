# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f4074c283dea83469e2fc68ac05a1f2"
SRC_URI[sha256sum] = "238f44c6f9377d9d28859ae4a956ad7078a0c1e32ea90704e5bb748d54cb7eae"
