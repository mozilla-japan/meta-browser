# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e4cda3fcbdd48bb61114b5d392d4ade2"
SRC_URI[sha256sum] = "22cf5832e4f65ac1f8340717b9ea53692e71b27a0b5fd33b2fb90e97bd242842"
