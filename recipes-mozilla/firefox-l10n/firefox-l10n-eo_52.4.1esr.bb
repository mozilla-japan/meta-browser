# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7f875a1fd33b50d3963a668786f15aca"
SRC_URI[sha256sum] = "8da68912ae78ab65b6f559200443cdb72b042be903b425f3d56cdb72f6a60a82"
