# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95d84bdb4d01a9e3d6f3b16d6755bcca"
SRC_URI[sha256sum] = "065578e6433c2a178f70f392a63d02c08e9589bcb5cb0c5220af1d15a810ab88"
