# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a51c91f13c365ac56eaa08448231bcb8"
SRC_URI[sha256sum] = "28ea0a58a799d5009c2e52f21ac819b34f624fe3db75666d42c8216bd49288ff"
