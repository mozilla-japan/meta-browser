# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2b10e102e00e7fd612bd762cf4a375a0"
SRC_URI[sha256sum] = "e82d1aa69411cb2dd44fd7f7b87a45e7b12f521740d6fd24f86633d1d4ff3bc3"
