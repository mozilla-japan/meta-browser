# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b0eb88dca773d61d3d3ece85a624e33"
SRC_URI[sha256sum] = "ab69572df3e393f21fcbbb320db1866b180ef0db7e44cf777de19ff32ad5071c"
