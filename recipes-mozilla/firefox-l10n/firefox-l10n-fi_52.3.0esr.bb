# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "350223da37b120f8c1c696166cef4d99"
SRC_URI[sha256sum] = "62c5f927f1c265170eb65e748b9b005dcbcca2b25d26b9f593aec0dbf1ed5c16"
