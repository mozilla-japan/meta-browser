# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc28930cb310278c8e5a3bb1602bdcbc"
SRC_URI[sha256sum] = "7ba26e286a54fe7789ce6b8218ed8656c3b171a9ad1d3d42498064cb858081fb"
