# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0b937d2cbb23556b18c81fa4dced5864"
SRC_URI[sha256sum] = "3d409c919b6a5fc3d1c937fb42eddece2a5fcfa98c878cb69160dc6aad6e104f"
