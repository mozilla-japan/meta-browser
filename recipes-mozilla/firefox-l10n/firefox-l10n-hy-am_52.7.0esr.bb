# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "447c2670f4126a887120c60761411acb"
SRC_URI[sha256sum] = "eee8e6734f56a6541400525829cfc4247a0bc6ee540b5ea247cf3786ca58b9f5"
