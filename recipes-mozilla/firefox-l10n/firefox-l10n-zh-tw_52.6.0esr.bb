# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "46948b0a4932c024e1dc98248cbc3447"
SRC_URI[sha256sum] = "b66bcc4c71b7c612a9fe260858d3c7bde7666d1684265b0c3d15e53a8991f3bf"
