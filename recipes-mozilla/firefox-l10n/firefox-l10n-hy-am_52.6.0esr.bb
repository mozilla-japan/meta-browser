# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd49e28a1d0c1688676420ba3f453e75"
SRC_URI[sha256sum] = "f4cdfe86b473e57634dc886a4005b9be27f721ff473b682a71b6f02ca9756463"
