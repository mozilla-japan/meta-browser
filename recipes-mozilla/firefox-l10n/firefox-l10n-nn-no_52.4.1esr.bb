# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "99a83b9df787454d445697045b9bab44"
SRC_URI[sha256sum] = "6acbded5336021ea911c6829c240583a82473edfb55c14fecf29352af84ce251"
