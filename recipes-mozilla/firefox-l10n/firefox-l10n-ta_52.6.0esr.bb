# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30f5e5fa2576641cbde0d07b122543d8"
SRC_URI[sha256sum] = "4369e5f7047f4e89519980dde7c316848e13997bd51588f7125132959a16aaa2"
