# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36bbd518dd4f5af472965e7d0ae4f134"
SRC_URI[sha256sum] = "f5a4d490ac1afbdd466695abff863fb593bb7a8200a0bbef3360ae29b0934e8a"
