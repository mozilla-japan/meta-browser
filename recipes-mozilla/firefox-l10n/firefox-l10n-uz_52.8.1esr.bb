# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a87cdff1286850d6c6e79eb0dd6de77b"
SRC_URI[sha256sum] = "9eb7a5a39428d9ff751a555cbf28c0148ad3d81ba63e20ad09aea880d96584c8"
