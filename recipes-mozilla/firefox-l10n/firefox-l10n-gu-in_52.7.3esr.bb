# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c544c1213207d1dc020638f5d13d753b"
SRC_URI[sha256sum] = "61d306921db5f89c86566fd75efa375fcb872fbca52cd4dd97715278018939be"
