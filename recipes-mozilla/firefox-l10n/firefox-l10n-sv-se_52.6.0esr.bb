# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c8b6e647ce8c872478b467849d6094db"
SRC_URI[sha256sum] = "d5c3fc435af689107d239fdeced800653dfbe4c90790d05ec2b7280e5c2b0fa5"
