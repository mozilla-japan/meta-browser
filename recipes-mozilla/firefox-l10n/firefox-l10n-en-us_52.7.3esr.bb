# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b809e4570d078c70a75afcdab3a2bada"
SRC_URI[sha256sum] = "533768d0438df810a0da9688ea1ad665f5e19ee9ea903c9f71e2451535d74e70"
