# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "362900bc161228a087e0a09d0814bfd4"
SRC_URI[sha256sum] = "35289fe1110076233906539c8880b69f2aeaea4d0d12cc5698edea5e6e269710"
