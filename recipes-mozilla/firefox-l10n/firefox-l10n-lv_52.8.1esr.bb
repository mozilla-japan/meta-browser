# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa332c38cc5d0953989cf55a021cc36a"
SRC_URI[sha256sum] = "145ba020a416c5af0782d48771ad0362856656553bc26f90a20df2ae20cfc74f"
