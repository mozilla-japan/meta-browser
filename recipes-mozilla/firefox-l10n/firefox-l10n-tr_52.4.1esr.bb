# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "56bd5110be6efeb61b800e9c97eec638"
SRC_URI[sha256sum] = "f163f221cf7c8d63c4f008173a2f054b6aa203ce5ece047214b2032400cd2d3f"
