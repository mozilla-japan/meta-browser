# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "77c09d79cb3cc125938ced0b0d761555"
SRC_URI[sha256sum] = "28cabf15e445e3bc169a07748622ec2560c24729158c25ed8a492423888b29dc"
