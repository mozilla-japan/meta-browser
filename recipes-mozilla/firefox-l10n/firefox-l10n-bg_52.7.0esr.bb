# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c9ae2a87f07af2f5083c3991db3d7a1a"
SRC_URI[sha256sum] = "f2f8b78da572c31d5b4e70a339a8bcb0d25d976208699dffe76ed91daebc1d1c"
