# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d3bd816d3c29ef58ab65990cd054d3ad"
SRC_URI[sha256sum] = "d235650a27e2278a6dc23c5beb624f1b19882dcaf1300366654f786b978b65a3"
