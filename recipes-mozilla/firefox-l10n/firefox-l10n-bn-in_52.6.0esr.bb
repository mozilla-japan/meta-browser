# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a74d118d27cd0340dd2cb4321a7ffcd4"
SRC_URI[sha256sum] = "88e4169d4fb0849e8355340705ed39186e65af5d3bab0fc2ade8f8d01f6f834e"
