# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d54b72cf91b3ddbed3add999c506c848"
SRC_URI[sha256sum] = "742bb40fc9135788b97e14e8b7d9caada46c8c72f98ab3aba17a024aea67ec24"
