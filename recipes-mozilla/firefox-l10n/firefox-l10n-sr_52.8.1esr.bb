# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f0bc1d239255c7ed85c3974fce8d1a96"
SRC_URI[sha256sum] = "9a8429db94323a1bcfcd53c29dc77b1c36006c25ac0810a4c38d688d5518b0df"
