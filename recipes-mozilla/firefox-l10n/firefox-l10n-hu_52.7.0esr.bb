# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2ed3061f728170dc761b363598195e10"
SRC_URI[sha256sum] = "f338536bcd13f5129da08d6718d6153b84f9f85af37e190e52231d646bc80ccb"
