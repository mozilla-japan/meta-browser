# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "852684287b104295fde773c5e46fc276"
SRC_URI[sha256sum] = "302de6b9073eb123c88e7683b797c0b426bccfa2311d24c126555f14d1647753"
