# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c8978cb51a33e9842f68069ff592bf8f"
SRC_URI[sha256sum] = "79139bac850fcb2c35f0abb466c82540efa742624b4a8ee90858b3ab7e704b65"
