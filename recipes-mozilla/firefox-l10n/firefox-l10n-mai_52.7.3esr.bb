# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "67afd4e4da0d53af46d15a1ee1590ff3"
SRC_URI[sha256sum] = "6d7a068ad510e96b034e6ceb4448ced6e7480d823d6f29454075c58a038df447"
