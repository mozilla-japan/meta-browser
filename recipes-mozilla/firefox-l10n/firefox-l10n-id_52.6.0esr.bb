# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "86663a5cfaea453ce1f02f21a4803271"
SRC_URI[sha256sum] = "2023fa8f5dd0017fbc93b3d1004c74fd58679167454fd90c8df5796b6070a5a3"
