# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "09a953c9dbbeda7c70682e95d24f9613"
SRC_URI[sha256sum] = "5b13c349310424b0d5abc05298bb891f10bd2ffa85eaf48bfc0fd52525de69d3"
