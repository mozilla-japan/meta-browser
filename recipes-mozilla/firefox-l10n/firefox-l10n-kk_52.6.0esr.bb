# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4bff841afa41ddd39dab988f96d68c3a"
SRC_URI[sha256sum] = "16062f201c591e55c0121324921473e4bce353af425f016c956303afecf89ca8"
