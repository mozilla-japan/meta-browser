# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "49ac81b83523d9314ae557f65e1c840a"
SRC_URI[sha256sum] = "8b0dd1121198116b35b1a24076fdcd0818dd04482b7ac1fc9f57da915ea1444d"
