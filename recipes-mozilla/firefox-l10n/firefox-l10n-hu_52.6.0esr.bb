# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "feb952b9bc6a68fbefb2c3fe4447f76f"
SRC_URI[sha256sum] = "1b8e6bf7c740e9da0801362e9081aa5e4ae1c5c7c1dcc6087e75be6cdf88ea43"
