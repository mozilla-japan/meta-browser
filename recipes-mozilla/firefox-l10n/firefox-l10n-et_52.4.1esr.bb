# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7998360886fe13b447dfaa9de015ae0"
SRC_URI[sha256sum] = "bfdc67a62f72ef89fe5132505cf8d2f3a66c52db753158f7e4c45d00f9f9c634"
