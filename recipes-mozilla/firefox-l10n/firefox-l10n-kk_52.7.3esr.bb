# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "529a9e9cd40759f9ae045db6f6f07bc7"
SRC_URI[sha256sum] = "7d4c0a1eabe19b3e0beb6b3a7e0bddf079767b0bb0eeb26f2ea82efc31a50e8b"
