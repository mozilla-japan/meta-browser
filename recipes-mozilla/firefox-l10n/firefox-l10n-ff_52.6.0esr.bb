# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7a46e5e2fe6269d2e9f6e601f574206"
SRC_URI[sha256sum] = "84eec2904035d3388dc8b56e80b6dbd0a9747cb5e1ac6f9ba2f393c27d2a4008"
