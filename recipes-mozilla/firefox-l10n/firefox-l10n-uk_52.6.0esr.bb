# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a27a23fb19e639e94f5a71402b67257f"
SRC_URI[sha256sum] = "6c5bb185967dae256871a8a01690fdd13425df3e43dde5c67fb4ffaf31cb205e"
