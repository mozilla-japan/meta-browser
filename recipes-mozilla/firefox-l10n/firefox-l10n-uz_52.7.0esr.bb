# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f00ef213e5497dffd1f9d3e6b4746619"
SRC_URI[sha256sum] = "6f4c1679ab26bcfc9b84fcd398ab6c45122e092914706e43f56f4640c696a6a6"
