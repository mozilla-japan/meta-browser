# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "48c5b6362ca3c530223abaeefbfbc0b2"
SRC_URI[sha256sum] = "e59310284b6034c665e8c294fa1733aabc267929aae2d00008e7601b4fc6af4b"
