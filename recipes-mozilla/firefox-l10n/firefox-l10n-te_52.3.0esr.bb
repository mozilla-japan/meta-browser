# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1ae3c870aaf294b33024aa319ea91742"
SRC_URI[sha256sum] = "21abd4943f8e041eb3028391fc8212f2080f04796cce8bebd5156afc029cc481"
