# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "19f5a437e9c263c983f392b8e9b0cc0c"
SRC_URI[sha256sum] = "e3e7d5e42e0ed8a74b0eb5fa215095a56094ab826f812319d7faf057f76ec488"
