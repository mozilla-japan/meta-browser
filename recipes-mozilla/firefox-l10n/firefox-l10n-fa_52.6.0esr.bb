# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "898ff2003389903a2f57166aa3585fb3"
SRC_URI[sha256sum] = "0ffbe98db610d53cf6c98d918af534096230d505c6b40c5fd7cfcc98253bce5e"
