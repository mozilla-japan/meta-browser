# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "33dc1cfc99622e93166beb1ebff64e4a"
SRC_URI[sha256sum] = "2df09f7facb021332ce80ec7b1105d5ba9d79b1f56372e5b96ff9b1af7258a3e"
