# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e90882bee369ad6191b746ff9fb0328c"
SRC_URI[sha256sum] = "f30011faf1a7f37c96934000b92c76b41bf6a9f5499233bdea063e92554c193b"
