# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bdabea616b091f50cb2122f3e36b3fcd"
SRC_URI[sha256sum] = "a44e8e0c256c0a2b252ccd950d3757f1deaf57f1ebfa3d03484bff5ffd7329a2"
