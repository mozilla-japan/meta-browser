# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b4a2c24eb2990b5bc1a95e4bc5166bb3"
SRC_URI[sha256sum] = "73083b4b384df8975fd6beb0d96e931856b30e7d4244938c20f1e599e5c74489"
