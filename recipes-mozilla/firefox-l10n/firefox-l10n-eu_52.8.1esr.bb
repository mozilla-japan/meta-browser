# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e8e85c6089808557f5ed26bb5ecb4b88"
SRC_URI[sha256sum] = "43a22c7b625f59b8347140b4378e8cb999dfdadedbe7b565ab45ff32ed10ead0"
