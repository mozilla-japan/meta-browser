# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9d5aba23ebdd318d39703f7499887dab"
SRC_URI[sha256sum] = "31eb9f0a2e1deb871d87d2d90cb6e809e2067b4a07dff1108088e4cb77a44943"
