# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32e5276dd97ad12f7baf7eb5c3ec851a"
SRC_URI[sha256sum] = "46fbc45894a97214b30a09919befab900a9aae5890ff7e7802c188cf036ab713"
