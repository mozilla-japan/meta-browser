# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "63e7600aa353462fa5b1c42a92732ffa"
SRC_URI[sha256sum] = "b5b4702bfd87d0cf4513de8f08044b7dd7c6a4718eee6b637287ad9b49407723"
