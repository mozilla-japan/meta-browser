# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f1fc94a0d4f9bd6dc6106b962749305e"
SRC_URI[sha256sum] = "92c45cad825c0a69862fc3622fb34fb31bf6740bfe83cbcf48fc976cad1b1d43"
