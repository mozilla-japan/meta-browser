# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce56a7d20358e0fa8e8082acbebcd70f"
SRC_URI[sha256sum] = "4d6bc9d58fb2feac75b0651f7d704b2da561e76d561101ab97723d1792c423b7"
