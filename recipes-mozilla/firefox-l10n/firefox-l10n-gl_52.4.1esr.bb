# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c2226fb177d08f573b255fb4bba34628"
SRC_URI[sha256sum] = "72fe76222086443dc04dffca41ed00bed4614bb742deb13c32ca6f65e79a1df0"
