# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3fce3f851fffebad70a7bfcf6d629f8c"
SRC_URI[sha256sum] = "60c3816f4fc6a92c7e244368eb4f702287b5745fe6ccc7ca5cf84d559cb44cd6"
