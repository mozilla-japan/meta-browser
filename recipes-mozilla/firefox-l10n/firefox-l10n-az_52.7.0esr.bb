# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "926ecf6fe38a29d9aca1649008085509"
SRC_URI[sha256sum] = "8aa50ba09aa86921bfeb44002fa5ab2f05de098a18a8ae681812cd9c2b597835"
