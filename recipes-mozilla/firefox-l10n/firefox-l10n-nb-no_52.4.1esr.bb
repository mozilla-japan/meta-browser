# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1c4906dec6f75a1e5f3b8fe2bada84e6"
SRC_URI[sha256sum] = "4c124d02d316c87f9649edfb5ed71643d97ed4a8a0ff0c114f23f368c12e5e77"
