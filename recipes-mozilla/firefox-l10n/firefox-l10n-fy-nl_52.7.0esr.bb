# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b8d81450833178968c2beffde1a55b4e"
SRC_URI[sha256sum] = "e2dd60cc92ede4781963e4e46bc394caf15e86308b7e00fd97542ba3e2d96687"
