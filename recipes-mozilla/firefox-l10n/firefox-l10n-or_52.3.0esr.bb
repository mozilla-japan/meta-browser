# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f76d084c1246737f448951ca4b86902c"
SRC_URI[sha256sum] = "e6fd7b8e2495fa5fa2e455dc93882fbe956bbd69ceb1028974f19c5134e9d18e"
