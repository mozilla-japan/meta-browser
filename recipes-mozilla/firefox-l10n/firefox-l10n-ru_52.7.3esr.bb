# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b14373c09ae443144558fcec9f9d1c16"
SRC_URI[sha256sum] = "99216563bb5b6f6d8c7bd069481c2f69d5537d22538f9ed909667e632a780ad9"
