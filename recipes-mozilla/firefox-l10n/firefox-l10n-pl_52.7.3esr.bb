# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bc8c139d9afd42b3e361dd6cf9b2497e"
SRC_URI[sha256sum] = "169e70aae7b89c50747d4a13a96802b1597ec3e0199d886025e528fd88e2b86b"
