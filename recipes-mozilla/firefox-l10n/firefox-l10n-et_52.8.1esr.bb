# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3dae168d4c4f5b8f31865644e7776e95"
SRC_URI[sha256sum] = "c87bbbb92dd7fe3c3b3755a7d10fd46f6ca57cfdefd00ba69291504df7c60d69"
