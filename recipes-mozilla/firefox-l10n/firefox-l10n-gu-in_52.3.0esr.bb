# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "616ecff5a4007b394b18f85b6c7e38b7"
SRC_URI[sha256sum] = "79a00a6a34ec1ddb108cc5aaa069e1fa63d26809b0bd3960de7ea1b95d521867"
