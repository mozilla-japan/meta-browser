# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eadaef5127cf2d71dbc2287960ea4bd0"
SRC_URI[sha256sum] = "ecae086f96f78153b71fb519e9cf3938fa8adad9f9d305858bbd579927edc264"
