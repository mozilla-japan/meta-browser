# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "92c8c61ff415d93eaa33c69384deb66d"
SRC_URI[sha256sum] = "5f55932665773e38fef424c099e11afca6f49f357b88861878a238b2bb0e3fb0"
