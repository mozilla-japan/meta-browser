# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "52a6793c71a788600146ae32b2446e15"
SRC_URI[sha256sum] = "29acfdef713913306dca8a3a5c720df92c855f8ebfb85c6a72563e05454001d7"
