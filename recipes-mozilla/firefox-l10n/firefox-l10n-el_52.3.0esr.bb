# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3241c32036c1d344675f63ee752d88a0"
SRC_URI[sha256sum] = "59fafef324b25195dce95869dd2caf80ae63608f9274a34b3378fe8f6881957f"
