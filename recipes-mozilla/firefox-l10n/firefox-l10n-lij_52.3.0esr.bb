# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e3f8eeff0f3a8e5ee7992357addef891"
SRC_URI[sha256sum] = "79e6bc6f251ae76c57f12e6262510e193236503a534fbfd5d162eab4663c8ee3"
