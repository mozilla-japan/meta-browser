# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "2962e400a2d870d2ead7cb4b8f345787"
SRC_URI[sha256sum] = "276fe6c551cda2d5f13c71c977c644ae7b71bcd0fee0fda42961501a5ce4be97"
