# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cde105d0c61380d3b9979e8fdfdbd94f"
SRC_URI[sha256sum] = "7e203d64c3f1171e49af45d1f7fe6e0ff1a551564fe7815b8e98050efbaa1b4f"
