# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e5565069777d013d65e342fa44b7f659"
SRC_URI[sha256sum] = "fe2bc47ea980b83b455651752d5fe5a45ae199445dfc977e5ddce872e34a55ad"
