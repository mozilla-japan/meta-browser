# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f283195a63fa3a40f3536b0df0e66d6"
SRC_URI[sha256sum] = "6e3f082abd61476672c23534f7f95b5002e49f08b0d953185e8c9f4faf289e01"
