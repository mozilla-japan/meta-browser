# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d4a52ad908dbdc06ebfa733b93fa01fe"
SRC_URI[sha256sum] = "1fca0f3d0ca1cda4a7d04564bbbd498040c4a6259361e576dac5ec7459d827ef"
