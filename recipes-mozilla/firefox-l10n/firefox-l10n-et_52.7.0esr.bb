# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "123bed0df10fde0d312911d8cd123adb"
SRC_URI[sha256sum] = "ea5b03674db13c574b88908c8865b0abb42b1f3bcc5d19ac7db8337e47d9ed28"
