# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "27ba43756374fe5ac79363862772843c"
SRC_URI[sha256sum] = "0b1baabcc30aab5a71404fa94313dadba270b786c4900948c0b26df12dbd6506"
