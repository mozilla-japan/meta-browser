# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "189995a2eebfc04facc0c7dc9f64abf8"
SRC_URI[sha256sum] = "dd16a14d44e2349dc9697ca7f5740e3a0c39af84a3449e51754bc0b66961b14d"
