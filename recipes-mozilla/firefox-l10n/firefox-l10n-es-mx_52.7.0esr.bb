# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "907b9278f17cd30bedd8ff7253b67c8a"
SRC_URI[sha256sum] = "f9b150ea730e13c80a6e046b91e8f7d13fed29d1b64fb3a41123eab95a745266"
