# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1e058b7e66101fb82eb7c34746eb063"
SRC_URI[sha256sum] = "5077e544192488aebec9f681188887f7d4a09264b8258a309abc4a6605b1a023"
