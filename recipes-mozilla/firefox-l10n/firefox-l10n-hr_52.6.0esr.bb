# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f0a816a0392b2e561f3ffdc4f5f451f"
SRC_URI[sha256sum] = "5188dd6ae015807de8745a5e14bd0e666998396ee190cea21a293028850009d6"
