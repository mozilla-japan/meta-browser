# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "74da9f3efcabfc51e1f86d84a1e39023"
SRC_URI[sha256sum] = "07e75a85757f215c97167e7f0a0c64681a57c0a930753c58c1ae57ed0ab7ce1c"
