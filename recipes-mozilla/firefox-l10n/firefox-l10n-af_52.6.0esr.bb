# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "49b75de5edd1f4b31098bc1bfed6668d"
SRC_URI[sha256sum] = "fb700f446801276d555460493bb9fb84271ec8393f89955216898ed35a9880fd"
