# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "78f00ebf608040dfb14020a209177273"
SRC_URI[sha256sum] = "fcbbe936c89164f1bc294b846936f603cd90ae3669d6a20aa2187766f0943371"
