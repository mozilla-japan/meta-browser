# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9449cf0616ad4e0e06c228555456aad6"
SRC_URI[sha256sum] = "a1d4e7260166048e4f19e5d633ab058edd84d3ae39515d243d3bdff8db08f8ce"
