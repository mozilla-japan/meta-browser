# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "07c7d5384ae0b21997a2567f81a90c7b"
SRC_URI[sha256sum] = "efaa0f33d619dc0fd5b2c4ca663b02051a0aaef260c41e6a6929af7a74e888c7"
