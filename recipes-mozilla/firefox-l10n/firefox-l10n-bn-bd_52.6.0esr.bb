# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fcfc84504d60d7b32b3c58b2fbf2b9d8"
SRC_URI[sha256sum] = "83f734695ee95bfc8062689411806e06a77749645d1d53f12f6bb0b0f8e9858d"
