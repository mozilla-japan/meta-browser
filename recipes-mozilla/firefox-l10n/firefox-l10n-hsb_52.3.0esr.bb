# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e692c329317037c99db6bf40bec78f81"
SRC_URI[sha256sum] = "89d2919938885e466d5ba0dd400a8e286f3b30aaef352c43af7db9d652d862ce"
