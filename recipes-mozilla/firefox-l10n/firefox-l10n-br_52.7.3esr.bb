# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "61acfb1f94bd8483788e2d519eb37bcf"
SRC_URI[sha256sum] = "28bc0a4aadf4392c6bc93030c3c596fc0f7089bd4cf27b8b1accfa5b91fba857"
