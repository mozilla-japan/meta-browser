# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a55122398bf43e43921cceaa533206c1"
SRC_URI[sha256sum] = "66f7a36ca1749241589355cc5b8c30b5db81a2c2eecbe50f77b94ee257e56103"
