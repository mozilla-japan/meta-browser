# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "713aed57b560f010faabc8db2adccd67"
SRC_URI[sha256sum] = "1e8764c7c48c50a0adb58c894b654204e0b95041164f659f82ef5b36def60ca1"
