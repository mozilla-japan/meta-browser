# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ed7239c03494b61d9aab69036ff4f56"
SRC_URI[sha256sum] = "2f640b578e7d16c7b8f2d589a59f9063d27f496b04740b8ee791b9286cc7b5ad"
