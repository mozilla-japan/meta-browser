# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8e973e60ae377d40f54a70d3943433e4"
SRC_URI[sha256sum] = "a0a71f63dcb977bacd20552986b180bd1737ae50aa3be81a9de1177d760277f2"
