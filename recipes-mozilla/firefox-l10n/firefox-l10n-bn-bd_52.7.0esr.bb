# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "23a3d5f8b9b07bd6dd8252e2bf004f5e"
SRC_URI[sha256sum] = "f3ac0bfcf90af4c91ee12a07cec65c8b8451f61d66c8d89d1266a9b2a7d9d8af"
