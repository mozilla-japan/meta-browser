# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9f99afead57e0350a469ba194a66f4d"
SRC_URI[sha256sum] = "e5f075e6cadc0d8cb1c53717f4f67f5e929a992508d9dcdb10d94ab8573cc1f9"
