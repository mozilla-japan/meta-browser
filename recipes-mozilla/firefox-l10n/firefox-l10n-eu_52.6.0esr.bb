# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f0530cc0d7c6319646adcdddad145782"
SRC_URI[sha256sum] = "3c75fe1cf197eed080b58587c49834171ca8d243765ae3eed5ebadc812cbfcb3"
