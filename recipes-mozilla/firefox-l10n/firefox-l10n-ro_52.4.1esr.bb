# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ae2f82b334baf686391cc7435c9452a0"
SRC_URI[sha256sum] = "8db46305e2f980d5086e5f44f59eabbf22232c6b9ea23fc40639d0bf56b91fc0"
