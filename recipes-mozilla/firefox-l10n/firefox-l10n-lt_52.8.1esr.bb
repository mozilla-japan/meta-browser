# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "727d7fefd1453e7bbdc7a7ca661871d6"
SRC_URI[sha256sum] = "73700ad9b92a57fa56ce2d38ebe9353cfd38594fe5ee438b8d67d92cbe790dec"
