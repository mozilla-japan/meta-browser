# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68fd6527021023832d13c6b46f1b2274"
SRC_URI[sha256sum] = "352aeed69b700d0048979d59327baa710ab362d15cd0937e67fc3f4a450184e0"
