# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "174eed5635a8ef5c7c6fc50148472038"
SRC_URI[sha256sum] = "a2e07054aee2805a553dcb9f0ab225839875df021f054a5d120fec7490a8551e"
