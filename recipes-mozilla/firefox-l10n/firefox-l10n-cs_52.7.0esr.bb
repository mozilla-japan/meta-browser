# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "78094307fb99532b012030756ff85f77"
SRC_URI[sha256sum] = "ff1da27ce3194c8dbe08db5c9f32dfde802bb88c5f71dfe26b4dea4b4a7da4c0"
