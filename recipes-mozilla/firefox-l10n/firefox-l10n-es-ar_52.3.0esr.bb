# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4ee8185026fb464a42894a8345054cdf"
SRC_URI[sha256sum] = "c30654478b3855f25946478656106052d44c30b5751c6a0354f064628b85c354"
