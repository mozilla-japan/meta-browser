# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a09a7b7e0b574aa3e01ef4bc79ad6da4"
SRC_URI[sha256sum] = "b4b0e72778e495ae9ff9376b15b7d98061c03698983f0673ce55580bd2f2275c"
