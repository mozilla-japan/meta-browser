# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eb404679d533451e183dbdb9da568500"
SRC_URI[sha256sum] = "ecca1b9fc44507a168e86e523f72078a1e88e7192df955911266840c4628d208"
