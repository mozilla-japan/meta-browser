# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dc685c9c3e6cad16418e69006c5db367"
SRC_URI[sha256sum] = "0a7dfad99076966f0a2a74eada5fda422b7fc57b12b1cf127bb0f9f5f55d00f6"
