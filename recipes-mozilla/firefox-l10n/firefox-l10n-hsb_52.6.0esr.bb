# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e11c60610d3b7b7e33042932b5e2ef1a"
SRC_URI[sha256sum] = "83147abce9594f785060811d6129093aba3c636d99af144e393c688b27bedccd"
