# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "cc041e03b728a3ca50e6bcd4be6f9d1d"
SRC_URI[sha256sum] = "ac4be21aef62ab9d1b48c83860f04fb38ab0edd14cf45afb2cece161bef38cfc"
