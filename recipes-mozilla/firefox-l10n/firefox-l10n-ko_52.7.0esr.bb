# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "802d72052b4969dd08e753298d68bdd3"
SRC_URI[sha256sum] = "e76358cbbe8e7e9c8ed186b44275b918140fce83ad4d094ee5fb7f840e5c9610"
