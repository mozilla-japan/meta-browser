# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "44eb78ca7f230560a244de68d696623a"
SRC_URI[sha256sum] = "66e8d0298fe9d186c2bd0a2b7e4d782d0dff07e2ac1e65b4d0132a6326640c35"
