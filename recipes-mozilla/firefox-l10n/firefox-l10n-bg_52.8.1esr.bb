# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68b447f8c94132abce5f2e072c709f06"
SRC_URI[sha256sum] = "f43c8f670535743f7ca6d26b21092b906beb5b095f5e5f3461457af074ea1420"
