# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1f13a3563ce32242499cb6f10d0bec50"
SRC_URI[sha256sum] = "1d66ad725fd3590ed53c586499d2273aeaccb5de1fa55c9a1f1e833ac862b657"
