# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "81795461094fd2485006ac53d6cbd494"
SRC_URI[sha256sum] = "23f1f3a5cf15197c091c82ea0eff16e34ff6db305d7d7b5766bb03ff31787229"
