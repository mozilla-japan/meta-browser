# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d98813a5642b18da2d8eb8e4aaff2e6f"
SRC_URI[sha256sum] = "25b6910724b67e380860aa8c30081b7a27d7afb4eb6410a7ec720679df3337d1"
