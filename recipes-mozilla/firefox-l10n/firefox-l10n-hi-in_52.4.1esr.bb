# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "25a0e739b8b7941b07e4284636cc5453"
SRC_URI[sha256sum] = "d55b375ed0d5d4e99528694aa85d9d9d45e5dde2ccdd8f93c6905198eb4bda4f"
