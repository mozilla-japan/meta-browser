# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f6bfd1a295867d6b364e84465d96c6c"
SRC_URI[sha256sum] = "e5f19e08912210755ad20bb3312b148986a9df30ea4b13423357a2f2dc5f58c8"
