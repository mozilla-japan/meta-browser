# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "12285caf182f91a612ebc3240454e8f5"
SRC_URI[sha256sum] = "1bac7681facb8cc8c04ac68f605bf97e2d8b4edb6c9cf1e98aa1dd379812ef13"
