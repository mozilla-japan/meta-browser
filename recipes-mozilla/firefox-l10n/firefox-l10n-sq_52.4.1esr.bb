# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "61c1c06eca1d876bbec4e1edefe4fb49"
SRC_URI[sha256sum] = "a666f16d8615dea1ca8df473724c99b0be9eeb8aae8a5368dee79ee9e50c8636"
