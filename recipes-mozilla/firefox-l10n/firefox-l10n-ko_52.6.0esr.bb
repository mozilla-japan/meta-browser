# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a066f5f26a6c3e0c892df33747b5824a"
SRC_URI[sha256sum] = "1d22a4331fb0a8cc4e504224cb7d60dcd372bd4fe55ed95ca965588879ae23f9"
