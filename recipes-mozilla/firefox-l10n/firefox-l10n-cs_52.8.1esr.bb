# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "22e4acad69ccc8c100973cb724dab894"
SRC_URI[sha256sum] = "a3128b01325bd9e39dcf0f98198096c0ed255a600c170dea0307a8f4faf2c0be"
