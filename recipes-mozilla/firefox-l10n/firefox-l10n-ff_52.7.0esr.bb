# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "80219822eb19b871edaf7494b906dcd6"
SRC_URI[sha256sum] = "cb2faa2fa72ba689b758354a952628cbb4925a78f20b82da1cb50df74dbbf31a"
