# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "76dd2a26405e77a847119036c90794ae"
SRC_URI[sha256sum] = "2612d7cad2fb5d865a03c3a414ec813333556b2e2a12766b4fb9774641aa9bf2"
