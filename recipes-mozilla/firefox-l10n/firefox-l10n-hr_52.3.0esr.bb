# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7987d788111f12b3df54ec23e26f727d"
SRC_URI[sha256sum] = "c04362df15f9b547e28afabe693837d23f5719dc2ba5cb226137e4a95a99a885"
