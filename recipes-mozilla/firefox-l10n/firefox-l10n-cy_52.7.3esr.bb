# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "eda86ad05ae2eaa252e3e11fb7ce0e75"
SRC_URI[sha256sum] = "48f5e6ff034d712614b763d7da1a884a8ebaaf9c3ccc4b8e82b61ce316823ada"
