# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4fe44ccc51f3793c599b07c3967856fe"
SRC_URI[sha256sum] = "9f322295725078d153f660c6d1a28cf869a12c79f9a80f9b53f66ac59b53e7fa"
