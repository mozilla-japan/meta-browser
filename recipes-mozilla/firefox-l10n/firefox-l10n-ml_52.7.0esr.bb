# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62e554ef87ae90a8aafd029184104ddc"
SRC_URI[sha256sum] = "331ca01d7cbc70995af2d2e16aaf1b161bb189ffe01c2154064affdec32c82d6"
