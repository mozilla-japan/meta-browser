# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3ff7034d8b7033f61ce9b15f8ae335f9"
SRC_URI[sha256sum] = "ae36e5eaccc28a51b359db234e6480359ae4d26c704427d27d7254b2ea00a93f"
