# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ad36e6055418286df55d43e612a731a3"
SRC_URI[sha256sum] = "1e98c66241272a50b90c3a590352ddb553df9047eefc5367bb9724090240edcb"
