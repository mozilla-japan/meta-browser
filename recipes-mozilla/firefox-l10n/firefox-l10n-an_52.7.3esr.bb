# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c30d9e3fa480cbc4027232d532e28931"
SRC_URI[sha256sum] = "9baa44ccd7f080afdbeb3cc82176dda0188d404a63da4a7c29eae1a4d2b3c9bc"
