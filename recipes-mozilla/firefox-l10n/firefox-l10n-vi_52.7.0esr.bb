# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9ba7acd8527ebefbe7afb831611a18af"
SRC_URI[sha256sum] = "5e369c1464d5ecdd12d84300b7e00b302f8614a0369efb654001dea1be7ccc4f"
