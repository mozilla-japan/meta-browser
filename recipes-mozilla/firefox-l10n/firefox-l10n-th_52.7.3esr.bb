# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7c4a3bec0f4812d9c1cdea382d70749"
SRC_URI[sha256sum] = "c732f15acd0fa3bce4ae0d8b34012d5b482616f37247c867ac9fbac24303b43a"
