# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4496a14812da3b2bb293668aa9502832"
SRC_URI[sha256sum] = "866d7fc1ce0966345904039a6e48687bca327328fb0a136cabbf203287bc6984"
