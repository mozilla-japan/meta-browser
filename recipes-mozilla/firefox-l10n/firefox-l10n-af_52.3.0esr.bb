# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a82bd4682aaf95de51100abfb3d03b71"
SRC_URI[sha256sum] = "207af367fa9f488aeacc765706cd94d7cf3c105ee457e705209d627037822dcc"
