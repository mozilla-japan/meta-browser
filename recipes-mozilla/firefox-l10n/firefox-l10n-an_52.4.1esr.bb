# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b25b1a9ada7e4ad599f75eccd8020bcf"
SRC_URI[sha256sum] = "6fd94a772a9c9a2beb62aeae2e8d3763e62143e4a8cd58e6b0a8145b9528a307"
