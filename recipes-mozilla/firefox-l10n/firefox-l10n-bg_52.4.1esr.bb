# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "ce134ca24b3262842de971a45aca9f4c"
SRC_URI[sha256sum] = "d6c08c1e0eb5f6fc710c8ecc58952bc5c64dd842ffe8b5212bf76a919f39f70b"
