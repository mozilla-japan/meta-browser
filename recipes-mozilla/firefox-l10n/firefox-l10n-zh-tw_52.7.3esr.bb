# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3fda510f98e554728db06f0015e1833d"
SRC_URI[sha256sum] = "40a520df44255079539d94302ed607b952b192cdc742fa5d3611b3bf81f39360"
