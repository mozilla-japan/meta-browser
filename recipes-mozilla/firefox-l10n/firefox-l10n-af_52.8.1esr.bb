# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c270fbfb621a4c296a7871b2efb4870d"
SRC_URI[sha256sum] = "95fc20ba901f3e0f5d2072c428a224bbc6de87fe0035ce583861b1e8ae12a2c4"
