# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e7278289dee437e646cd5f55bbcffa16"
SRC_URI[sha256sum] = "1b90567da9b863378f791d01777373df8aa7bb51118f9557b6bc2f9aca33de4c"
