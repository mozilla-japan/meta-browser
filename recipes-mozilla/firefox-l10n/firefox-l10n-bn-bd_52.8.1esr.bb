# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "230519a4e78e581f76608b51328fa5b2"
SRC_URI[sha256sum] = "4ac981e2276a1cb6c61cb68f15524c73a8d9d964b7dac61aba1a4fbec8677135"
