# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "30cdc5fbcb1d87d0ea9d469a9f85ddfe"
SRC_URI[sha256sum] = "97da8713003f7ee0c3260c6eda6ba0b27895c12f438e457a77d136bbd89943a2"
