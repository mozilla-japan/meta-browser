# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b0e44125fbd4dc83fc8e4e40ded04cb2"
SRC_URI[sha256sum] = "117d664eda5021935cae9440ecc84797aaaa412df90007ecd3de62300929fa08"
