# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "95a6c91364f8ae8b5ddffbfc7d6d3223"
SRC_URI[sha256sum] = "282cc71b5516b0a90e34c4a741ee16292afea4d65b538f161c1fde00b77977e0"
