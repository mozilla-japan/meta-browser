# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4eb01003e02f167c5c3777820d016711"
SRC_URI[sha256sum] = "6536468eea3a2a5c40e6c7b11c3e383678a09e813d1cf8bc65c6f2a679be48be"
