# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8eecd9b88959a609e79b80848bf70349"
SRC_URI[sha256sum] = "58ac90b38650ab4b9e448d1a07b6272346185c0ff797a107f1438fac4980e343"
