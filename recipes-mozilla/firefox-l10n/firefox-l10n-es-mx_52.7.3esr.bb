# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6fc81053554df8905d5b7afdfc31dfc4"
SRC_URI[sha256sum] = "a99a1f6acc048ea851b536ebd8798e6010af13c12cb29b8f4b8fabe4ba05e005"
