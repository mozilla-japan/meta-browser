# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "51a3326b158cd63792ca734da94c621a"
SRC_URI[sha256sum] = "24c716cb562bd577af85ffe09312070bdcd81bf7aedc5b2873a431adcad9d7dc"
