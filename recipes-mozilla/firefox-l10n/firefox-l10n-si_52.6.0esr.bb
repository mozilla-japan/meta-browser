# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d7217aa91805ed60b1d2f16b5de4646"
SRC_URI[sha256sum] = "821745c59c7c7c17829437760d040bd02ccb6273c60cf738c1bac3cab3a97fb2"
