# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3f3de35288dfaa71dd5eff6489c48356"
SRC_URI[sha256sum] = "db75d8b2ee4b59020befced4fecd2fdfb02afd7bc549aa946a027943f66987a9"
