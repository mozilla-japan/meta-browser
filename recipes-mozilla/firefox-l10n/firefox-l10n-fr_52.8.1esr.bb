# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dad8042df4bef7d39039a81b1c26d211"
SRC_URI[sha256sum] = "7caf043b2186db59edd483035c148686fc9d26bf2e635f709668905a09f76cf3"
