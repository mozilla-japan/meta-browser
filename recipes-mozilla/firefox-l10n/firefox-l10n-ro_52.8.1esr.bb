# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "36fdf89b2cde17029ee4bda30fcc518c"
SRC_URI[sha256sum] = "92a5017fb0c1080ce65b95048a4725041479faabab81290afc53a75c54837d17"
