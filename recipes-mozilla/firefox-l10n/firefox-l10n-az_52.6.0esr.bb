# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38cf930b41f5cc584b680c2104145dfe"
SRC_URI[sha256sum] = "1339a7ed59de39e1c7a6a7d8f34b9070b5e1665b21b8989888f3ada96a7e39e6"
