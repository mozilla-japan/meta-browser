# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1af2a5cf7dffe54dcd92fb20fb74609a"
SRC_URI[sha256sum] = "fe6b5002bf32098bec2900958dfe6fee6a738b3cf6bed34420ce3168ef6b5688"
