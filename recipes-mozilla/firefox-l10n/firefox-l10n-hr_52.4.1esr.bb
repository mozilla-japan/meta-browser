# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a9be009137bbe81a6b64581661f34ec2"
SRC_URI[sha256sum] = "28ed2dd9fd7ab017d5c8d4dcd30e7acde07bb9c50d4fcc7dfbade33b29342bbd"
