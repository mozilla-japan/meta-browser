# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bf8a6c63a5bf1173db928e77ff45a391"
SRC_URI[sha256sum] = "f41c413d7b0e2bd96776b5f400835ebea9483ed6ff8b36171f72653cf91326a8"
