# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6559cbf7e405c1c763ccba807b4d2b7f"
SRC_URI[sha256sum] = "5917ec73e61fd05657f9d11db5ddf0cd6dbcd404321c8313bb7756dd8afd677b"
