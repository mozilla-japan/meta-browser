# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "8b41e5cb0a8ea05ff2a3c439b7fce781"
SRC_URI[sha256sum] = "8bb3cb0ea6840683e06b77048d6dafefbe13e809afed20ddf3763c2bc0cb5789"
