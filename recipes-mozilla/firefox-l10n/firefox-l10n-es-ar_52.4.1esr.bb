# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "529496bec9e8302519411f4ab67348d6"
SRC_URI[sha256sum] = "8c499ba0d75122b4512d61e9a7840ce37f0aea3fd5c0d356e6ca33380be79840"
