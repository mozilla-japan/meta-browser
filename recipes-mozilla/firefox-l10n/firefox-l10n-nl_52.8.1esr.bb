# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d0c6fb3e0ad2dda4008e3032f58e3b82"
SRC_URI[sha256sum] = "6afbb9148a02506ed27d290c8607196b928fad0247763a4323d392fcd4aefbc8"
