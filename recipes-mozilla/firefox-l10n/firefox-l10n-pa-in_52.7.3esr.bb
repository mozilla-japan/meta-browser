# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "38cf7efd8e4234b58a202fe8a095e065"
SRC_URI[sha256sum] = "ac31b10bcfa8d11d70fd0fb6fe159c39eef2f6c9c56fec54634e028184747749"
