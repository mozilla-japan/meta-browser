# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "e1d32bc9c685e60d6b77ea66232f792e"
SRC_URI[sha256sum] = "e44a05d5be92f922591d9e8abb21e18b92d74eaf86395133a017e9ffbf17a073"
