# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "145bfa537ec9571e3feeca1c843ad815"
SRC_URI[sha256sum] = "b844fc2056fac3b25d45fc15d6b170a173e498a5a07b2cdb59d897819e40a699"
