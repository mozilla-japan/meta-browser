# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45bff77da63ad5740cb7b888f7692ef4"
SRC_URI[sha256sum] = "a6901d2e3851a6a19cbe38d67b44da10064c2c2c29008c4e71234548aeedce16"
