# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f7a7514cf33f6bd8b189de3d4c34b8ef"
SRC_URI[sha256sum] = "b21715d9ad575036bc0374bbf989b20720b3d3e71158e820bad67da481fab10d"
