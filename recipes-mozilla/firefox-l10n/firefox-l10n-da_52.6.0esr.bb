# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "0f00f5a1b8fefeadb44321472e7e458e"
SRC_URI[sha256sum] = "1a6430e139ac5ddfd09b5940b917c623196faecf9a9b86e6b7bb358fdefca5e7"
