# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fd1d59721dcef90f7d62a24251eef983"
SRC_URI[sha256sum] = "f91c51dc01faad2eba3b9da13a139309961d5b32c93f2e018864caf70a606acc"
