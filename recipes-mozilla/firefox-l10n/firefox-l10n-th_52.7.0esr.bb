# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6791ca9135243bdee02f3710a7ecdc30"
SRC_URI[sha256sum] = "71a1405f4ddad0ff3b3989b0d3c3ab936b487c8950c0d1ee9004dedcd1fb1170"
