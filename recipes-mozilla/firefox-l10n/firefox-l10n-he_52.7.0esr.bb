# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6c533b9ab70404afa46fa0a277ada5da"
SRC_URI[sha256sum] = "8e3ba942b7197861ac8e5697f462f27e0101c7ee7afa1b21c800cf84f168619d"
