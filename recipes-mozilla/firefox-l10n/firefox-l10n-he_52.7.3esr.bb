# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e2c38cabee2762b61c11cc3932ecc07"
SRC_URI[sha256sum] = "0dd8a3e7785ddf2c9a983281b8305213b16962ce89ab1d5f26bf07ac5a854347"
