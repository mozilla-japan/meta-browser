# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "094611b6a4fa62227ab818226171b935"
SRC_URI[sha256sum] = "b373c2f301d0c88486ba29fde7dcf10cf40011398b1efcfd19c8213afad6e8a7"
