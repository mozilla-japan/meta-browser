# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b38f5d35706a69d21640d91c4d7ccbf7"
SRC_URI[sha256sum] = "6eb3f00754d8966de6b73ea9126a479831111b4585af2fd3db801840119295d7"
