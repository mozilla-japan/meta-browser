# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4853dec8ac461b299786bf9b0ce16094"
SRC_URI[sha256sum] = "04c4c39bce8ac4798e9af14794dced620eca16dc448310f6ec860124243af1f6"
