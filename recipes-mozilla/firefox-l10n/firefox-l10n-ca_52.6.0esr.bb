# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bd971f210345af55c077b3fed4e23335"
SRC_URI[sha256sum] = "87823f075577d8bb25c969fe37a0af1e015868a1d33e51c8f0d717c0b2151ba8"
