# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4288f8d134c877d10e811af4963cfb5"
SRC_URI[sha256sum] = "767e298998ad290b3cd2dd15936362d1018fc2b1dd0ce2cf4fd4d2535d402f70"
