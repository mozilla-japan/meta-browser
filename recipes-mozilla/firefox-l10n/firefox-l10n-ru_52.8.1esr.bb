# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1cf6b1715ab1914eefaaf147d0ee5479"
SRC_URI[sha256sum] = "22ee5cc68c6b0b96e8a39b194c571d96f37f74a70739b0d69005442a3fdd63fd"
