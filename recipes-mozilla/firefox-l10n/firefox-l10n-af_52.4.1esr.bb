# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "15434b9c6a3bde461bb4ce671f39277c"
SRC_URI[sha256sum] = "eaa09839495f15c61241693fb4e96042ab5981bdacda5ff1ecf96ff67f77d40b"
