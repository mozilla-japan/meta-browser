# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "934e6f4759322401db7506f198277fe0"
SRC_URI[sha256sum] = "d0f665797352d92b431921fe45ae3dcf1cbf7f7e5d3253853b6aa673507e4218"
