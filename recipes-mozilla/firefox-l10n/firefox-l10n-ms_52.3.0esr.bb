# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6f976e40e76d86500e3548426bc140f8"
SRC_URI[sha256sum] = "59341afa10dbd2dbee2a5b2f1764d0949d7254104738b8e4a950138540d445d0"
