# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "fa9e837ef0181d3456daa40cdff73290"
SRC_URI[sha256sum] = "6f65cde6c0d1fdd25efc60ce7842340e8e608c65cd906383d0927ec3f30d2e35"
