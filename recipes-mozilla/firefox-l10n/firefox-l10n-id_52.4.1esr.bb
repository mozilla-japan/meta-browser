# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "05603823c0a54d4977fc15eb431ceb6a"
SRC_URI[sha256sum] = "f1dec750d3bd754cb47419fb23c0e27deecb661da495333f2d397e822bec7cd4"
