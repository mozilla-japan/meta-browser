# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "849fab2032220561c13c69556872093f"
SRC_URI[sha256sum] = "a53e53cfbb8e3f4f871980e4bf6d9bb5e7bf0adb45fe7272fd34337d5d0f0905"
