# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6bbc78fe4d3a9c5c3e2146448dff9392"
SRC_URI[sha256sum] = "19613a5e2c93bf460c4fc5e9e63b59e8de9916035c90b7b6f10eadc5ca2d6f2b"
