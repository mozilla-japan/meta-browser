# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68b76447522c411b194171ff318ec0bf"
SRC_URI[sha256sum] = "b2d33bd18f1fa363417554e6a0dccc51b493e4b87f312ad378be990057b017b8"
