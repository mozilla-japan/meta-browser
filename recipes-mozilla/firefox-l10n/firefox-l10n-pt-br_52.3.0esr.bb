# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "024259cecc3e8f366c01ba02ba03b0ae"
SRC_URI[sha256sum] = "06e1d14174175a2a7e507e6768c2da488d6c942bfc25e121ec8f98830d28ce7b"
