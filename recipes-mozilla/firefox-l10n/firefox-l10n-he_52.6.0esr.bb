# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d5641e8cfd92672ac3f0d52953193cc0"
SRC_URI[sha256sum] = "d152d9d9417c76286ec99d41de9e90f6367602e0dd43068f7046a696caf63475"
