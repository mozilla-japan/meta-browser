# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "522224431114139d170ef052cac33310"
SRC_URI[sha256sum] = "1254dc79973bceb1f50ef4c5806cbb9b05be71ed7b4019b524a120429efd2c4b"
