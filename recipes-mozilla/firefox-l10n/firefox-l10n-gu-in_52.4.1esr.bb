# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "a0a7c26b502fe5422c446caf10eaa302"
SRC_URI[sha256sum] = "ee4343a36c72e9c50c359c0169f6f61d9e04f4e3dafb2aea55316826189d6477"
