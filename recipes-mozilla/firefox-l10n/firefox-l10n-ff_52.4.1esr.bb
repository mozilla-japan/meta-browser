# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "00d4adb2c2b657f2a6dd02c4da9d6444"
SRC_URI[sha256sum] = "9f52b77989b2020f9557c5508276fee48488bd38a0e212b8c086ecadd5a24e84"
