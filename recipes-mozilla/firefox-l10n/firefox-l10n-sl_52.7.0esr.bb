# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "62dd8b69e6ff7c85d096f10c365a2eb8"
SRC_URI[sha256sum] = "c26851221a1362db015f3072d306c9480fa9dc518dcbfe6d79774a91cf69de97"
