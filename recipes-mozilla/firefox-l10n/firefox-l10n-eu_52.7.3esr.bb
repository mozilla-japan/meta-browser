# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f4c6a51070f5d83b2856575812e40068"
SRC_URI[sha256sum] = "5a575446586f0d652d201f9bf97b80cb9441fdd3f7be0f25fa7f6ff6798ebe65"
