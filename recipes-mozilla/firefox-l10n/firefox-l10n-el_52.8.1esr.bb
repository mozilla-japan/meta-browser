# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1833b27c4c55e7f60e690fb10913555e"
SRC_URI[sha256sum] = "a95bc7e9bb9b2a6bb4020c95d938315ae747f529714d164ef4020b9bc4fb26ba"
