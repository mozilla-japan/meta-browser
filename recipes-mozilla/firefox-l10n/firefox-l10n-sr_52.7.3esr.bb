# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9e7806f4e9627ddacc02ba40cfaad464"
SRC_URI[sha256sum] = "75ccf2fad4fd0400ce77fb178307069e54ed28f078c596ffbb3fc11b1dade405"
