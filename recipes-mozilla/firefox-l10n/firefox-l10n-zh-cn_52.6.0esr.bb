# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3eab6448c109f9d3585643a4a6071639"
SRC_URI[sha256sum] = "bf93d65cb7bab6d999ae9a4dd4ecb509c2661141f39659fa2c8c921e92c2e5a5"
