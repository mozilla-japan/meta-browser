# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5fdb52a9382bb1ef000932c3a2912525"
SRC_URI[sha256sum] = "04b66cd227d63d88af75966da3fb7af63dd4c9cd895b426b4316b6f3b6fca06a"
