# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "3b0f37434b2bc543042d7cdad3359458"
SRC_URI[sha256sum] = "80e832c64933cc0f0cc0d3ac00ebb3bfc395a2837d3d98b190e007990a0f4179"
