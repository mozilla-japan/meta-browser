# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "516ecd78a7c2c58a8d7ca00ccc573a5d"
SRC_URI[sha256sum] = "ad127b95648f3876bd3e25bb6aa30500afb2255ed6c44aebfad1c78a89937db6"
