# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "55e0d41e0bcbeb904254d1461b99a7ef"
SRC_URI[sha256sum] = "d9d2ab4e10b02b580d4d921fbbf6ca9d60b6b5e03553b9357e13798e8c7c77e7"
