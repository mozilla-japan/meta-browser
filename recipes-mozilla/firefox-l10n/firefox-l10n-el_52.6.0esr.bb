# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "58603d0cb87a42e39b88e5d8d4b9cbe7"
SRC_URI[sha256sum] = "2e2f5db8d523d3bbc366464b8143a7d37a6c76d9eb85d540dd0c48eb29bde43b"
