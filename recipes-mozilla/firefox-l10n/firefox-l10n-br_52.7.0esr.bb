# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "af56feaee87eef483c1768d6d99cf947"
SRC_URI[sha256sum] = "a4988f38e4d22160086d728a5a887932da10960f463c7da37498248e94b70dbe"
