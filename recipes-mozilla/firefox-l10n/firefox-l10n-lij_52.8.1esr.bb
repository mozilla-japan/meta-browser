# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "7ab0a74e20fb4db60481205e6559246b"
SRC_URI[sha256sum] = "4c23b76cf4e49401ca2eefb3e72cf89f32076e25866e5bb75582a189a54098ab"
