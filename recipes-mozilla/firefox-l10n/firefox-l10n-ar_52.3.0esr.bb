# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "78e8f09f9f79e53e2d783aed84141bf2"
SRC_URI[sha256sum] = "0e8b755d190e1c55eecb7821ee2069d680695bef0a89b10cb4b53f65baa67b17"
