# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "14c567815328331dc7cd81438efc29b8"
SRC_URI[sha256sum] = "3c43915cffec3bbf8feba0bccbee57d5fefb6f75d72b2e0b7b1754cc87d4362f"
