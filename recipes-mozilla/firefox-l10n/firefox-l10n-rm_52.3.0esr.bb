# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "237cddb13e41053884c7729318f7866d"
SRC_URI[sha256sum] = "b1ec6987f5b522c59bb77fc85e1469c498c2017d449e9232ddda1f7da2bd72de"
