# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "45800437c4377b45a5c29e2b30726890"
SRC_URI[sha256sum] = "2f671ad06b15921869e0f73c863cb20532349f97f6c1b9821a5a1513e643ec27"
