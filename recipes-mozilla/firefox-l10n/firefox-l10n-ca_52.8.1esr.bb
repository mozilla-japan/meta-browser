# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "32da79329d04c785ba8231c188a98b0d"
SRC_URI[sha256sum] = "cf1d1ac0cdc75281c5a7bee8b228a44a34afcfbd83213a23e744877dc6f262d2"
