# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f3f80968b9115b21d162c113b23f676a"
SRC_URI[sha256sum] = "50e4384bef4ae84f0cd1317b83c4fb895f25b38ef1b9864897a6fb7299426ef2"
