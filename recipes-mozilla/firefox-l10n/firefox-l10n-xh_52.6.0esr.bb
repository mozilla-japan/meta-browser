# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "b14abb37b6c68bd416a2b467ca8cce65"
SRC_URI[sha256sum] = "aaf84fd012ac37cfd8b730002738ebf63504cb4c815020655cae02eb6097c704"
