# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "faa9c0b86f4654100579765ce5c7261e"
SRC_URI[sha256sum] = "319e9a47bf54214d88e9f94200f907d56cfd2877fc7959e4a1c7f20410c07ca2"
