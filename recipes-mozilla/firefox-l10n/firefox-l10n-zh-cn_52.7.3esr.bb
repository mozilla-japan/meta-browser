# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "bce9a0b064661a98c2c67da980bfe9a7"
SRC_URI[sha256sum] = "f63d65c74ec1b39731dbb0d7d7afe6d957fc347b11417953a5d850d52d75ffea"
