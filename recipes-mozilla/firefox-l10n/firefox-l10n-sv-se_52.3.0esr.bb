# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "d2eff7b631f9072519c55da8eab5bace"
SRC_URI[sha256sum] = "2037a612d56dab5c05b452b37ea8bc37cd836b01246f66463b11c644cbe1d4d2"
