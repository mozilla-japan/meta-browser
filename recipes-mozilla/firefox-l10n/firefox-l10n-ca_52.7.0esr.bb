# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "4b8b1eb56fa39dfa4b507de6150643be"
SRC_URI[sha256sum] = "4ef6abfe8b1971923d2e24e8793b6caca6e9999d8937406f0fed51ad0786b6e6"
