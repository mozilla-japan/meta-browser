# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "c7555be6465be6da842a8cb9c8a6b5e9"
SRC_URI[sha256sum] = "8a0b4fef0abf9c98af56c49e57c36473b2aa387eb7cd8959ec79dd2941ee3ae7"
