# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "311f39c644f2a19041e9bf9e8fa5f813"
SRC_URI[sha256sum] = "04f35c740f43a4d48bd5c5a3feba707c844467d1ec25662e7b2c04f8aec0157b"
