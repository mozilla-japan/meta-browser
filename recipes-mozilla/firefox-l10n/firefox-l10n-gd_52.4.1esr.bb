# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "63c6691acb844438da6d2314343865f4"
SRC_URI[sha256sum] = "937004dcffb2b2501f54397c965772eaf8a936d754a74fd7c94d28cb6335fcb9"
