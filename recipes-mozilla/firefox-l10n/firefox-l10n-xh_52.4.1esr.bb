# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5ffaa37be9d62cceb14a0a08157d6d8c"
SRC_URI[sha256sum] = "2f38d135bc53ca3f02a741e63f7d955322f1906755013df9ce821648e7b18d6d"
