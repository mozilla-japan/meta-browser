# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "db01e87a387a4a256da84469d4368631"
SRC_URI[sha256sum] = "6e3151a9fc1ba63c11b9603e9b48e461758b54a2d8abb81579e595d15e3d329a"
