# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1235dfa93a7bc0a975a4fc91e6c372cc"
SRC_URI[sha256sum] = "8f7ed993a8875d93b47c4a92cab06438689a058231d37fd635b6a9675bcbdf4c"
