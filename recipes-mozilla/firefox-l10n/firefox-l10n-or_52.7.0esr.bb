# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "90b4e9790d26531694bda7423f0161f1"
SRC_URI[sha256sum] = "05b6e3cde361bb707934f20a3359d6196dd78ae80676bd9b11c272d34d468735"
