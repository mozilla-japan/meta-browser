# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9272f728439fa2f4ca49d36c5946042c"
SRC_URI[sha256sum] = "c1e2110ce2613ff693b034067b89a1725ad04b2d826927433d4f1413ea138a37"
