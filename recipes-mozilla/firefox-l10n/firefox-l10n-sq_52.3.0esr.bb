# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9966e21a668a808807d4ec8ab4b70096"
SRC_URI[sha256sum] = "0f43fcf1e3f8b5cc2c9a625b9b3adead743101d278568dc040ee16224920b213"
