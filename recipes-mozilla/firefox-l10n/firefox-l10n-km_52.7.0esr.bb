# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9c4534ba4b561ddd38ad0d450652199d"
SRC_URI[sha256sum] = "7bf1701014db5d8869af2c13b92c9cc8a651d029b16ca9b2ba4ad7d1bfe14598"
