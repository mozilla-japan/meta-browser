# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "1a79f506754be29371162316355cdd4c"
SRC_URI[sha256sum] = "94747b5e4ad531a57945abb45903fcd954b61c3b34340cc765abebb7f8a2ee6d"
