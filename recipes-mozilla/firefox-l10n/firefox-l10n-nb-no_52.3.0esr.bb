# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6ea2aee7797979962db8f2c11186234d"
SRC_URI[sha256sum] = "e9a3814fa0244b9b1955a44e2659e58f35318785db1fc1ed39b47ef7e90d5b68"
