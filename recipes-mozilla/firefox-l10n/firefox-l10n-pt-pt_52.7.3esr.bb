# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "97cc4ed414e2e16901e8a89273275850"
SRC_URI[sha256sum] = "4c40bb78681f7a5e859508b4dcc7419df29bd645b355d954916b109d68d15ce5"
