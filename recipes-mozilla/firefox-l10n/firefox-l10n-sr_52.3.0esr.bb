# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9fdd3b6bb40787331cf3832c826d79fd"
SRC_URI[sha256sum] = "78e9bd35f77e2286711c141be0462bdecd071ead330c3f2118bbc9dd8c67d56c"
