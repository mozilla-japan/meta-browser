# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "17337190b97bddb02beddaff568f8dae"
SRC_URI[sha256sum] = "b5d75397a8f1290cd9613e2dece0a85f2e65866493b07d9fc900212a64214559"
