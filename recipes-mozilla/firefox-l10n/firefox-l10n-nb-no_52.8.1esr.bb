# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "dbec3932a271adde816883a0cccd6207"
SRC_URI[sha256sum] = "a36926083ec566c395599643de82928948aac42bf0d01170ae61dce64b578303"
