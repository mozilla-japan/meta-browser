# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "5d6a01acde3f317e821342b0d5c71821"
SRC_URI[sha256sum] = "9769f32bc6a043cc578d941f3feb29ebc190510715b32b7a960e7b53f1956235"
