# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "29aea5f1b6e06046bba8e97ecaeb3873"
SRC_URI[sha256sum] = "53550ec4df5815e81f5ea768ab5296ec7af9d697db9a830f1c57a5f73e9c500d"
