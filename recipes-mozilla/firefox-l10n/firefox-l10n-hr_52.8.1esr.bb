# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6312e52981c7bf4b281850108d8ec0aa"
SRC_URI[sha256sum] = "fdb0ef19ea743e969dfee5003e3ad6d11effab45e7e8c21c9748fccb674c1104"
