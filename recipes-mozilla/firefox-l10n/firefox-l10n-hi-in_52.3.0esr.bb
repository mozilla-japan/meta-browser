# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "f608abb30566bc140c8c69e588825261"
SRC_URI[sha256sum] = "54873b68e7ba70b2b5c49d2c053bb8db6f1263c90300e1a8dd072d3f8054b5f8"
