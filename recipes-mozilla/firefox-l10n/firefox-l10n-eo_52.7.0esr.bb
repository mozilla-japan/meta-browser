# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "9f10f3517e47feb6b4ebfeb5b09a6760"
SRC_URI[sha256sum] = "ef7eff25895357e25606cc31b3425ea4cfbad175e0689d6f3687c15bff1a8380"
