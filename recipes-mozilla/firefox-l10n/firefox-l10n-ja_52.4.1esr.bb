# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "68e1a1e69b961840aaecd50f6973fe28"
SRC_URI[sha256sum] = "018a8573a15ecf2ac1dbfa731f144d649f00685de9d0d34385844fe90df84dd2"
