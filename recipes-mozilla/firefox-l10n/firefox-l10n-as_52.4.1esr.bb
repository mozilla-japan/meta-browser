# Copyright (C) 2009-2016, O.S. Systems Software Ltda. All Rights Reserved
# Released under the MIT license (see packages/COPYING)

require firefox-l10n.inc

SRC_URI[md5sum] = "6a54ef4952c4c058c7d209b9e506b060"
SRC_URI[sha256sum] = "65db8246313533e6aa148c977597647572639957899445d067fa79da98baedeb"
